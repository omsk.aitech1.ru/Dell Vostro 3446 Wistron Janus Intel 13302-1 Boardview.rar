# Allegro board Janus Intel MB_13302-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
JDREF: length 3.3
  TOP w0.102: HDA27.15 37.03,14.23 37.21,14.41 37.21,15.22 36.62,15.8 v2(36.62,15.82) 36.62,16.72 R2707.1
JGND:
  vias: v3(105.82,150.91) v3(105.83,150.06) v3(105.85,151.79) v3(106.69,151.74) v3(106.69,150.91) v3(106.69,150.06)
KB_BL_CTRL: length 95.3
  TOP w0.102: v1(176.11,32.5) 176.12,32.5 176.52,32.1 KBC24.22
  L3 w0.102: v1(137.36,71.05) 139.67,68.73 139.67,50.39 147.71,42.35 147.71,40.21 150.77,37.15 150.77,35.24 151.51,34.5 151.51,31.95 154.61,28.85 154.84,28.85 155.48,28.21 155.48,27.87 159.76,23.59 162.68,23.59 163.63,22.64 167.43,22.64 167.5,22.71 172.25,22.71 172.69,22.27 177.67,22.27 178.46,23.06 v1(179.12,23.06)
  L4 w0.102: v1(176.11,32.5) 176.77,31.84 176.77,29.69 178.43,28.03 178.43,23.74 v1(179.12,23.06)
  BOTTOM w0.102: v1(137.36,71.05) 137.36,69.93 R6208.1 139.24,69.54 139.44,69.74 v2(139.44,69.97) 139.44,70.55 139,71 Q6202.G
KB_BL_CTRL#: length 43.7
  TOP w0.305: 132.27,104.56 131.26,104.56 KBLIT1.4 131.25,104.56 130.12,104.56 AFTP6247.1
  TOP w0.508: v1(135.19,101.11) 135.19,101.63 132.27,104.56
  BOTTOM w0.508: v1(135.19,101.11) 135.19,101.32 135.86,101.98 136.77,101.98 138.1,100.66 138.1,98.87 137.51,98.29 137.51,97.39 137.87,97.03 137.87,94.32 136.22,92.67 136.22,91.28 136.95,90.55 136.95,88.54 137.41,88.08 137.41,82.57 135.35,80.51 135.35,73.68 136.13,72.9 Q6202.D
KB_DET#: length 137.8
  TOP w0.102: v1(190.48,81.39) 190.02,81.39 189.45,81.96 KB1.30 191.3,82.26 AFTP6202.1 192.12,83.09 192.12,87.66 196.63,92.17 196.63,99.63 199.86,102.86 199.86,109.79 200.37,110.3 KB2.30 ; RN2002.5 121.77,94.44 v1(121.21,93.87) 121.21,93.25 120.72,92.77 120.72,91 120.24,90.51 120.24,89.96 120.41,89.79 120.41,89.16 v1(120.2,88.94)
  L3 w0.102: v1(155.65,96.33) 154.89,97.09 154.14,97.09 153.64,96.59 153.07,96.59 152.76,96.89 150.74,96.89 149.57,95.72 149.32,95.72 149.32,95.72 143.8,95.72 143.2,95.12 136.9,95.12 v1(136.62,94.84)
  L4 w0.102: v1(136.62,94.84) 137.18,95.39 137.18,96.82 136.73,97.27 135.99,97.27 135.81,97.1 132.97,97.1 132.81,96.94 131.06,96.94 130.96,97.05 129.39,97.05 128.57,96.23 126.9,96.23 124.57,93.91 121.24,93.91 v1(121.21,93.87)
  BOTTOM w0.102: CPU1.K2 118.37,87.99 118.58,88.2 118.58,88.94 118.8,89.17 119.71,89.17 119.93,88.94 v1(120.2,88.94) ; v1(190.48,81.39) 190.48,84.98 192.87,87.37 192.87,89.31 193.59,90.03 193.59,90.86 189.56,94.88 185.53,94.88 184.7,95.72 174.82,95.72 174.41,96.13 174.04,96.13 173.37,96.79 156.1,96.79 v1(155.65,96.33)
KB_LED_BL_DET: length 40.6
  TOP w0.102: v2(120.85,89.58) 120.67,89.76 v1(120.67,90.14)
  L3 w0.102: v1(140.31,77.06) 139.82,77.54 139.82,82.67 140.92,83.76 140.92,84.58 138.56,86.94 134.07,86.94 133.11,87.9 133.11,88.27 132.26,89.13 131.11,89.13 130.55,89.69 130.55,90.72 129.74,91.53 128.47,91.53 127.11,92.89 125.74,92.89 125.65,92.98 122.14,92.98 121.73,92.56 121.73,91.2 v1(120.67,90.14)
  BOTTOM w0.102: v1(140.31,77.06) R6207.1 R6206.1 ; CPU1.J1 119.09,88.93 119.48,88.93 119.88,88.54 120.37,88.54 120.73,88.9 120.73,90.08 v1(120.67,90.14)
KB_LED_DET_C: length 35.6
  TOP w0.102: AFTP6246.1 130.22,102.56 131.25,102.56 KBLIT1.2 133.32,102.55 134.39,101.48 v1(134.39,101.08)
  BOTTOM w0.102: v1(134.39,101.08) 134.39,101.34 135.6,102.54 137,102.54 138.76,100.79 138.76,98.49 139.19,98.06 139.19,93.77 138.1,92.69 138.1,91.28 138.79,90.59 138.79,80.28 C6203.1 139.42,79.66 R6206.2
KBC_BEEP: length 159.6
  TOP w0.203: KBC24.118 172.09,21.31 172.39,21.02 v1(172.39,21)
  TOP w0.254: RN2701.1 41.09,24.36 41.26,24.18 v2(41.78,24.18) 42.25,24.18 v1(42.43,24.35)
  L4 w0.254: v1(42.43,24.35) 51.34,15.44 58.08,15.44 58.97,16.32 64.16,16.32 66.74,13.74 71.26,13.74 79,6.01 104.86,6.01 108.11,9.25 110.01,9.25 112.18,7.08 124.94,7.08 125.44,7.57 126.18,7.57 128.27,9.66 136.69,9.66 138.29,8.05 143.59,8.05 144.27,8.73 147.7,8.73 147.7,8.73 148.86,8.73 148.86,8.73 152.74,8.73 154.57,6.9 158.75,6.9 158.75,6.9 161.87,6.9 162.43,7.46 164.99,10.02 170.67,10.02 172.2,11.56 174.14,13.49 174.14,20.04 173.18,21 v1(172.39,21)
KBC_BEEP_R: length 3.7
  TOP w0.254: v2(41.98,22.98) 41.8,23.16 RN2701.4 40.7,21.88 D2701.1
KBC_DPWROK: length 66.8
  TOP w0.127: v1(158.95,29.05) 159.06,28.95 159.87,28.95 160.22,29.3 v2(160.25,29.3) 160.83,29.3 161.22,29.7 KBC24.81
  L4 w0.127: v1(124.75,58.58) 124.21,58.04 124.21,57.43 124.76,56.88 126.91,56.88 128.62,55.16 129.09,55.16 129.92,54.34 129.92,54.07 131.95,52.04 131.95,47.25 133.97,45.23 133.97,43.91 134.77,43.12 136.09,43.12 136.83,43.86 137.29,43.86 138.03,43.12 140.89,43.12 144.19,39.82 144.68,39.82 146.1,38.4 146.82,38.4 147.41,37.8 147.9,37.8 148.12,37.8 149.52,36.39 149.52,33.94 151.46,32 154.57,32 154.77,32.21 154.77,34.34 155.2,34.77 155.2,34.77 155.42,34.99 157.13,34.99 157.8,34.33 157.8,32.54 158.95,31.39 v1(158.95,29.05)
  BOTTOM w0.127: R1718.2 125.34,61.16 EC1705.1 125.34,60.39 125.46,60.28 R1725.2 125.46,59.86 124.75,59.15 v1(124.75,58.58)
KBC_ON#_GATE: length 6.2
  TOP w0.102: Q2403.G 154.14,31.36 Q2402.G 154.14,30.58 154.03,30.47 C2417.1 153.67,29.35 v2(153.08,29.35) 152.55,29.35 R2433.2
KBC_ON#_GATE_L: length 4.3
  TOP w0.102: R2431.1 154.01,28.85 R2433.1 152.17,28.1 151.95,27.88 v2(151.6,27.88) 151.33,28.15 R2432.2
KBC_PWRBTN#: length 158.4
  TOP w0.102: v1(159.68,42.95) 159.68,44.46 150.84,53.3 v2(150.84,55.72) v1(150.84,56.45) ; v1(101.41,129.58) 101.03,129.95 R6102.1
  L3 w0.102: v1(101.41,129.58) 101.41,129.01 101.88,128.54 111.63,128.54 111.85,128.76 114.96,128.76 116.05,127.67 121.09,127.67 121.09,127.67 121.45,127.67 121.45,127.67 121.53,127.67 125.85,132 131.85,132 132.3,131.54 133.43,131.54 134.58,130.4 136.91,130.4 142.43,124.88 v1(142.43,124.87)
  L4 w0.102: v1(159.68,42.95) 162.36,40.28 162.61,40.02 162.61,40.02 162.62,40.01 162.62,39.02 165.3,36.35 165.3,33.32 166.64,31.98 166.64,28.73 v1(164.93,27.03)
  BOTTOM w0.102: v1(150.84,56.45) 149.99,57.3 149.99,58.66 147.01,61.64 147.01,66.74 146.44,67.31 146.44,80.32 146.86,80.74 146.86,86.98 147.39,87.51 147.39,90.02 146.86,90.56 146.86,99.06 144.29,101.64 144.29,111.02 142.77,112.53 142.77,124.52 v1(142.43,124.87) ; v1(164.93,27.03) 165.27,27.03 165.57,26.72 R2427.1
KBC_PWRBTN#_C: length 6.7
  TOP w0.127: SW1.4 97.55,133.97 97.7,133.82 97.7,133 97.45,132.76 97.45,131.99 97.64,131.81 98.33,131.81 98.54,132.02 AFTP6801.1 98.85,131.42 99.43,130.84 EC6104.1 R6102.2
KBC_VCORF: length 3.5
  TOP w0.203: C2416.1 171.18,40.24 171.68,40.24 171.98,39.94 v2(171.98,39.87) 171.98,39.77 171.74,39.53 171.74,38.65 171.69,38.6 KBC24.44
KCOL0: length 102.6
  TOP w0.102: KBC24.53 168.09,38.8 168.69,39.4 168.69,40.44 169.8,41.55 169.8,41.94 170.23,42.37 170.23,46.61 175.66,52.05 175.66,62.28 AFTP6207.1 177.82,64.43 178.32,64.43 182.09,68.21 182.09,81.28 183.89,83.08 183.89,90.98 186.08,93.17 187.31,93.17 187.91,93.76 187.91,94.99 188.77,95.86 KB1.13 190.66,95.86 192.34,97.53 192.34,98.34 192.34,100.22 193.62,101.5 193.62,110.92 196.4,113.7 196.4,121.09 199.22,123.9 200.55,123.9 KB2.13
KCOL1: length 100.9
  TOP w0.102: KB2.15 200.55,122.3 199.46,122.3 196.81,119.65 196.81,104.12 192.74,100.05 192.74,98.85 192.74,96.73 190.27,94.26 KB1.15 188.63,94.26 188.31,93.94 188.31,93.6 187.48,92.76 186.25,92.76 184.3,90.81 184.3,82.91 182.5,81.11 182.5,67.59 AFTP6206.1 177.19,62.28 177.19,53.71 176.16,52.68 176.16,51.97 171.68,47.48 171.68,42.93 v1(171.7,42.9) ; v1(170.69,42.91) 170.69,42.54 170.01,41.86 170.01,41.46 168.9,40.35 168.9,39.32 168.49,38.91 KBC24.52
  BOTTOM w0.102: v1(171.7,42.9) 170.7,42.9 v1(170.69,42.91)
KCOL2: length 100.8
  TOP w0.102: KB2.14 200.55,123.1 199.34,123.1 196.61,120.37 196.61,104.21 192.54,100.14 192.54,98.77 192.54,98.77 192.54,98.26 192.54,98.26 192.54,97.2 190.4,95.06 KB1.14 189.15,95.06 188.11,94.02 188.11,93.68 187.4,92.97 186.17,92.97 184.1,90.9 184.1,82.99 182.3,81.19 182.3,68.12 176.89,62.72 176.89,61.48 AFTP6226.1 175.87,60.45 175.87,51.96 171.24,47.34 171.24,42.71 170.93,42.4 170.84,42.4 170.21,41.77 170.21,41.38 169.1,40.27 169.1,39.23 168.89,39.03 KBC24.51
KCOL3: length 100.8
  TOP w0.102: KBC24.50 169.29,38.64 169.3,38.65 169.3,40.18 170.41,41.29 170.41,41.69 170.92,42.19 171.82,42.19 172.39,42.76 172.39,47.91 176.36,51.88 176.36,52.6 177.39,53.63 177.39,61.98 AFTP6208.1 183.46,68.05 183.46,76.69 185.12,78.35 185.12,80.91 184.94,81.09 184.94,84.18 184.5,84.62 184.5,90.73 186.33,92.56 187.56,92.56 188.46,93.46 KB1.16 191.36,93.46 192.95,95.05 192.95,98.09 192.95,99.97 197.01,104.04 197.01,118.88 199.64,121.5 200.55,121.5 KB2.16
KCOL4: length 99.6
  TOP w0.102: KBC24.49 169.69,40.29 171.02,41.62 v1(171.02,41.66) ; v1(173.45,41.9) 174.17,42.61 174.17,46.51 179.68,52.02 179.68,58.17 AFTP6224.1 180.87,59.36 180.87,63.67 184.27,67.07 184.27,76.36 185.93,78.01 185.93,80.81 185.93,80.81 185.93,81.24 185.75,81.42 185.75,84.52 185.32,84.96 185.32,90.38 186.06,91.13 188.28,91.13 189.15,90.26 KB1.20 190.19,90.26 190.7,90.77 190.7,91.32 194.6,95.22 194.6,100.47 197.83,103.7 197.83,116.54 199.59,118.3 200.55,118.3 KB2.20
  BOTTOM w0.102: v1(171.02,41.66) 171.41,42.05 173.3,42.05 v1(173.45,41.9)
KCOL5: length 100.5
  TOP w0.102: v1(173.49,41.26) 174.37,42.14 174.37,46.42 181.3,53.36 181.3,61.82 AFTP6215.1 182.24,64.74 184.48,66.99 184.48,76.27 186.13,77.93 186.13,80.72 186.13,80.72 186.13,81.33 185.96,81.5 185.96,84.61 185.52,85.05 185.52,90.3 186.15,90.92 188.19,90.92 188.59,90.53 188.59,89.73 188.86,89.46 KB1.21 190.74,89.46 190.9,89.62 190.9,91.23 194.8,95.13 194.8,100.39 198.03,103.62 198.03,115.85 199.68,117.5 200.55,117.5 KB2.21 ; KBC24.48 170.09,40.4 170.91,41.21 171.2,41.21 171.6,41.61 v1(171.66,41.61)
  BOTTOM w0.102: v1(173.49,41.26) 173.41,41.26 173.04,41.63 171.71,41.63 171.7,41.61 v1(171.66,41.61)
KCOL6: length 100.3
  TOP w0.102: v1(171.54,40.95) 170.93,40.95 170.49,40.51 KBC24.47 ; v1(172.95,40.58) 172.95,40.83 172.79,40.98 172.79,45.79 176.77,49.76 176.77,52.43 178,53.66 178,59.89 180.2,62.09 AFTP6223.1 180.2,63.57 183.87,67.24 183.87,76.52 185.52,78.18 185.52,81.08 185.35,81.25 185.35,84.35 184.91,84.79 184.91,90.55 186.22,91.86 KB1.18 190.33,91.86 193.35,94.88 193.35,97.92 193.35,99.1 193.35,99.1 193.35,99.8 197.42,103.87 197.42,118.17 199.16,119.9 200.55,119.9 KB2.18
  BOTTOM w0.102: v1(171.54,40.95) 171.82,40.67 172.86,40.67 v1(172.95,40.58)
KCOL7: length 99.7
  TOP w0.102: KBC24.43 172.09,38.78 172.15,38.84 172.15,38.84 172.26,38.95 172.26,39.47 172.5,39.71 172.5,40.13 172.31,40.32 172.31,40.84 172.13,41.02 v1(172.13,41.19) ; KB2.19 200.55,119.1 199.25,119.1 197.62,117.48 197.62,103.78 193.55,99.72 193.55,99.19 193.56,99.19 193.56,97.84 193.55,97.84 193.55,94.63 189.99,91.06 KB1.19 188.69,91.06 188.42,91.33 185.98,91.33 185.11,90.47 185.11,84.87 185.55,84.43 185.55,81.34 185.73,81.16 185.73,78.09 184.07,76.44 184.07,67.15 180.67,63.75 180.67,61.19 AFTP6213.1 178.29,58.81 178.29,50.92 173,45.63 173,41.14 173.35,40.78 173.41,40.78 v1(173.58,40.62)
  BOTTOM w0.102: v1(172.13,41.19) 172.13,41.19 172.31,41.01 173.13,41.01 173.52,40.62 v1(173.58,40.62)
KCOL8: length 98.5
  TOP w0.102: KBC24.42 172.49,39 172.46,39.03 172.46,39.39 172.7,39.63 172.7,40.21 172.51,40.4 172.51,40.96 172.56,41.01 172.56,41.37 172.56,41.37 172.51,41.42 172.51,41.85 172.59,41.93 172.59,47.82 176.57,51.8 176.57,52.52 177.59,53.54 177.59,60.15 AFTP6231.1 179.81,62.37 179.81,63.47 183.67,67.32 183.67,76.61 185.32,78.26 185.32,80.99 185.14,81.17 185.14,84.27 184.71,84.7 184.71,90.64 186.42,92.36 186.97,92.36 187.65,92.36 187.95,92.66 KB1.17 190.85,92.66 193.15,94.96 193.15,98.01 193.15,98.01 193.15,99.02 193.15,99.89 197.22,103.95 197.22,118.6 199.32,120.7 200.55,120.7 KB2.17
KCOL9: length 114.4
  TOP w0.102: v1(172.9,39.21) 172.9,38.53 172.89,38.53 KBC24.41 ; v1(167.77,39.1) 168.35,39.67 168.35,39.94 168.4,39.99 168.4,41.23 167.74,41.89 167.74,45.85 173,51.11 173,62.89 173.2,63.1 173.2,64.17 175.21,66.17 176.95,66.17 AFTP6219.1 180.88,70.1 180.88,81.78 182.67,83.58 182.67,91.49 184.94,93.75 184.94,95.9 187.73,98.69 187.73,99.34 188.39,100 188.39,100.3 188.53,100.43 188.75,100.66 KB1.7 190.66,100.66 192.4,102.4 192.4,111.42 195.18,114.21 195.18,125.46 198.43,128.7 200.55,128.7 KB2.7
  BOTTOM w0.102: v1(172.9,39.21) 172.64,39.21 171.99,39.86 168.83,39.86 168.28,39.31 167.99,39.31 v1(167.77,39.1)
KCOL10: length 121.1
  TOP w0.102: KBC24.40 173.29,38.64 173.46,38.81 v1(173.46,38.85) ; v1(164.77,39.06) 164.51,39.31 164.51,40.25 166.24,41.98 166.75,41.98 167.32,42.54 167.32,46 172.3,50.99 172.3,62.78 171.93,63.15 171.93,64.41 AFTP6232.1 174.7,67.18 177.15,67.18 180.47,70.5 180.47,81.95 182.27,83.75 182.27,91.66 184.53,93.92 184.53,96.07 187.32,98.86 187.32,100.41 188.53,101.62 188.53,101.99 188.8,102.26 KB1.5 190.12,102.26 191.99,104.13 191.99,111.59 194.78,114.38 194.78,126.41 198.67,130.3 199.16,130.3 199.16,130.3 KB2.5
  BOTTOM w0.102: v1(173.46,38.85) 173.38,38.78 172.69,38.78 171.81,39.66 168.95,39.66 167.96,38.67 165.16,38.67 v1(164.77,39.06)
KCOL11: length 115.4
  TOP w0.102: KB2.6 199.14,129.5 199.13,129.5 198.64,129.5 194.98,125.85 194.98,114.29 192.19,111.51 192.19,102.88 190.77,101.46 KB1.6 188.66,101.46 187.53,100.33 187.53,98.77 184.74,95.98 184.74,93.84 182.47,91.57 182.47,83.67 180.67,81.87 180.67,70.41 177.08,66.82 AFTP6220.1 175.93,66.61 175.36,66.61 173,64.25 173,63.18 172.51,62.69 172.51,50.9 167.54,45.93 167.54,41.69 167.76,41.47 167.87,41.47 168.2,41.14 168.2,40.07 167.94,39.82 167.88,39.82 v1(167.8,39.74) ; v1(173.43,39.55) 173.89,39.09 173.89,38.63 173.69,38.43 KBC24.39
  BOTTOM w0.102: v1(167.8,39.74) 168.42,39.74 168.74,40.06 172.18,40.06 172.55,39.69 173.29,39.69 v1(173.43,39.55)
KCOL12: length 109.2
  TOP w0.102: KBC24.38 174.09,40.48 v1(174.24,40.63) ; v1(168.96,41.32) 169.15,41.32 169.6,41.77 169.6,42.03 170.03,42.45 170.03,46.7 175.46,52.13 175.46,62.58 177.67,64.79 AFTP6233.1 181.89,68.51 181.89,81.36 183.69,83.16 183.69,91.07 185.96,93.33 185.96,94.16 188.46,96.66 KB1.12 190.54,96.66 192.13,98.25 192.13,100.31 193.41,101.59 193.41,111 196.2,113.79 196.2,122.03 198.88,124.7 200.55,124.7 KB2.12
  BOTTOM w0.102: v1(168.96,41.32) 169.21,41.32 170.16,42.27 172.63,42.27 172.76,42.4 173.56,42.4 173.92,42.03 173.92,40.95 v1(174.24,40.63)
KCOL13: length 111.3
  TOP w0.102: v1(168.68,42.67) 168.68,46.21 173.41,50.94 173.41,62.56 174.28,63.43 175.19,63.43 176.06,64.3 176.06,64.71 AFTP6203.1 176.74,65.39 177.24,65.39 181.28,69.43 181.28,81.62 183.08,83.41 183.08,91.32 185.35,93.59 185.35,95.73 188.68,99.06 KB1.9 190.02,99.06 192.8,101.84 192.8,111.25 195.59,114.04 195.59,124.59 198.1,127.1 200.55,127.1 KB2.9 ; KBC24.37 174.49,38.7 174.42,38.78 174.42,39.36 v1(174.7,39.64)
  BOTTOM w0.102: v1(168.68,42.67) 168.74,42.61 168.74,41.73 168.53,41.52 168.53,41.14 169.2,40.47 172.45,40.47 172.77,40.15 173.13,40.15 173.17,40.18 174.16,40.18 v1(174.7,39.64)
KCOL14: length 112.8
  TOP w0.102: v1(168.3,42.04) 167.94,42.4 167.94,45.76 173.2,51.03 173.2,62.64 174.34,63.78 174.34,64.09 175.84,65.59 176.94,65.59 AFTP6216.1 181.08,69.73 181.08,81.7 182.88,83.5 182.88,91.4 185.14,93.67 185.14,95.81 187.93,98.6 187.93,99.26 188.54,99.86 KB1.8 190.53,99.86 192.6,101.93 192.6,111.34 195.39,114.12 195.39,125.12 198.17,127.9 200.55,127.9 KB2.8 ; v1(174.85,38.96) 174.89,38.91 KBC24.36
  BOTTOM w0.102: v1(174.85,38.96) 174.77,38.96 173.75,39.98 173.25,39.98 173.22,39.95 172.65,39.95 172.33,40.27 168.65,40.27 168.32,40.59 168.32,42.02 v1(168.3,42.04)
KCOL15: length 110.8
  TOP w0.102: v1(169.31,42.64) 169.31,46.56 173.61,50.86 173.61,62.26 AFTP6229.1 174.58,63.23 175.37,63.23 180.74,68.6 180.76,68.6 181.48,69.33 181.48,81.53 183.28,83.33 183.28,91.23 185.55,93.5 185.55,95.63 187.74,97.82 188.37,97.82 188.82,98.26 KB1.10 190.62,98.26 191.73,99.37 191.73,100.48 193.01,101.76 193.01,111.17 195.79,113.96 195.79,123.78 198.32,126.3 200.55,126.3 KB2.10 ; v1(175.59,40.18) 175.59,40.18 175.59,40.12 175.29,39.83 KBC24.35
  BOTTOM w0.102: v1(169.31,42.64) 169.52,42.64 170.22,43.34 173.19,43.34 174.33,42.2 174.33,41.45 174.88,40.9 174.88,40.89 175.59,40.17 175.59,40.18 v1(175.59,40.18)
KCOL16: length 110.2
  TOP w0.102: v1(175.73,39.26) 175.73,39.29 175.69,39.26 KBC24.34 ; KB2.11 200.55,125.5 199.04,125.5 196,122.46 196,113.87 193.21,111.09 193.21,101.67 191.93,100.39 191.93,98.34 191.05,97.46 KB1.11 188.42,97.46 188.27,97.61 187.82,97.61 185.75,95.54 185.75,93.42 183.49,91.15 183.49,83.25 181.69,81.45 181.69,69.24 175,62.56 175,61.62 AFTP6225.1 173.81,60.43 173.81,50.77 169.82,46.78 169.82,42.54 169.31,42.02 v1(169.17,42.02)
  BOTTOM w0.102: v1(169.17,42.02) 169.62,42.02 170.07,42.47 172.5,42.47 172.63,42.6 173.64,42.6 174.12,42.12 174.12,41.36 174.67,40.81 174.67,40.45 175.73,39.4 v1(175.73,39.26)
KROW0: length 108
  TOP w0.102: KB2.22 199.64,116.7 199.64,116.7 198.23,115.3 198.23,103.53 195.01,100.31 195.01,95.05 191.11,91.15 191.11,89.37 190.4,88.66 KB1.22 189.18,88.66 188.39,89.45 188.39,90.17 188.09,90.46 187.27,90.46 186.9,90.1 186.9,86.17 187.17,85.9 187.17,81.23 187.67,80.73 187.67,78.92 185.58,76.83 185.58,70.32 184.97,69.7 184.97,67.19 183.22,65.45 183.22,61.71 AFTP6228.1 181.51,60 181.51,53.27 174.62,46.39 174.62,41.75 v1(175.56,40.81) ; v1(167.76,40.37) 167.36,39.98 167.36,39.3 167.34,39.28 167.34,38.87 167.69,38.52 KBC24.54
  BOTTOM w0.102: v1(175.56,40.81) 175.46,40.91 175.22,40.91 174.53,41.6 174.53,42.29 173.28,43.54 168.94,43.54 167.87,42.47 167.87,41.54 168.12,41.29 168.12,40.73 v1(167.76,40.37)
KROW1: length 103.4
  TOP w0.102: KB2.24 200.55,115.1 199.44,115.1 198.64,114.3 198.64,103.36 195.41,100.14 195.41,94.88 191.81,91.28 191.81,89.08 190.8,88.07 190.8,87.42 190.44,87.06 KB1.24 188.9,87.06 188.5,86.66 188.5,85.99 187.58,85.07 187.58,81.4 188.07,80.9 188.07,78.75 185.99,76.67 185.99,70.15 185.37,69.54 185.37,68.69 185.37,64 184.27,62.89 AFTP6227.1 184.27,61.65 182.71,60.09 182.71,58.37 181.91,57.57 181.91,53.11 175.16,46.35 175.16,42.61 175.44,42.32 175.61,42.32 175.89,42.05 175.89,41.09 176.24,40.74 v1(176.24,40.69) ; KBC24.55 167.29,38.63 167.14,38.78 167.14,39.36 167.16,39.39 167.16,40.51 v1(167.69,41.04)
  BOTTOM w0.102: v1(176.24,40.69) 176.24,40.74 175.74,41.24 175.17,41.24 174.73,41.68 174.73,42.37 173.36,43.74 168.86,43.74 167.67,42.55 167.67,41.06 v1(167.69,41.04)
KROW2: length 100.9
  TOP w0.102: v1(166.73,39.5) 166.73,39.24 166.88,39.1 166.88,38.76 166.89,38.74 KBC24.56 ; KB2.26 200.55,113.5 199.61,113.5 199.04,112.93 199.04,103.19 195.82,99.97 195.82,94.71 192.22,91.11 192.22,88.91 191.21,87.9 191.21,85.87 190.8,85.46 KB1.26 189.01,85.46 187.98,84.44 187.98,81.57 188.48,81.07 188.48,78.58 186.4,76.5 186.4,69.98 185.78,69.37 185.78,68.86 185.78,63.83 185.31,63.36 185.31,59.73 AFTP6218.1 184.27,57.7 183.59,57.02 183.59,54.04 177.63,48.09 177.63,44.94 176.2,43.5 176.2,42.49 176.1,42.38 176.1,41.88 176.55,41.42 v1(176.59,41.42)
  BOTTOM w0.102: v1(166.73,39.5) 167.26,40.03 167.26,41.22 167.35,41.31 167.35,42.21 167.35,42.52 168.77,43.95 173.44,43.95 174.94,42.46 174.94,41.77 175.25,41.45 176.57,41.45 v1(176.59,41.42)
KROW3: length 102
  TOP w0.102: KB2.23 200.55,115.9 199.78,115.9 198.44,114.56 198.44,114.39 198.44,114.39 198.44,103.45 195.21,100.22 195.21,94.96 191.31,91.06 191.31,88.88 190.29,87.86 KB1.23 188.82,87.86 188.3,87.34 188.3,86.08 187.37,85.15 187.37,81.31 187.87,80.81 187.87,78.83 185.78,76.74 185.78,70.23 185.17,69.62 185.17,67.1 183.43,65.36 183.43,61.1 182.24,59.91 AFTP6234.1 181.71,58.17 181.71,53.19 174.95,46.43 174.95,42.36 v1(175.43,41.88) ; v1(166.5,40.09) 166.29,39.88 166.29,39.26 166.49,39.06 KBC24.57
  BOTTOM w0.102: v1(175.43,41.88) 175.14,42.17 175.14,42.54 173.53,44.15 168.69,44.15 167.15,42.61 167.15,42.3 167.14,41.5 167.05,41.41 167.05,40.65 v1(166.5,40.09)
KROW4: length 100.1
  TOP w0.102: KB2.27 199.85,112.7 199.25,112.09 199.25,103.11 196.02,99.88 196.02,92.43 191.41,87.82 191.41,85.61 190.47,84.66 KB1.27 188.98,84.66 188.19,83.87 188.19,81.65 188.68,81.15 188.68,78.49 186.6,76.41 186.6,69.9 185.98,69.28 185.98,68.95 185.98,68.95 185.98,65.79 186.3,65.47 AFTP6230.1 186.3,64.06 185.51,63.27 185.51,58.66 183.79,56.94 183.79,53.83 183.13,53.17 183.13,50.66 180.31,47.85 178.85,47.85 177.84,46.83 177.84,44.85 176.53,43.54 v1(176.53,42.05) ; v1(166.41,40.85) 166.06,40.5 166.06,38.42 166.09,38.39 KBC24.58
  BOTTOM w0.102: v1(176.53,42.05) 176.27,42.31 175.6,42.31 175.34,42.57 175.34,42.62 173.61,44.35 168.61,44.35 166.94,42.69 166.94,42.38 166.94,42.38 166.94,41.59 166.85,41.5 166.85,41.29 v1(166.41,40.85)
KROW5: length 100.1
  TOP w0.102: v1(166.42,41.49) 166.42,41.48 166.22,41.28 166.21,41.28 165.96,41.02 165.96,40.89 165.86,40.79 165.86,38.68 165.69,38.51 KBC24.59 ; KB2.25 200.55,114.3 199.53,114.3 198.84,113.62 198.84,103.28 195.62,100.05 195.62,94.79 192.01,91.19 192.01,88.99 191.01,87.98 191.01,87.28 189.99,86.26 KB1.25 189.06,86.26 187.78,84.98 187.78,81.48 188.28,80.98 188.28,78.66 186.19,76.58 186.19,70.07 185.58,69.45 185.58,68.78 185.58,63.92 185.1,63.44 185.1,61.56 AFTP6214.1 184.04,60.73 182.92,59.6 182.92,58.39 183.39,57.92 183.39,54.15 175.65,46.42 175.65,42.87 v1(175.77,42.75)
  BOTTOM w0.102: v1(166.42,41.49) 166.42,41.48 166.74,41.8 166.74,42.47 166.74,42.77 168.52,44.56 173.71,44.56 175.52,42.75 v1(175.77,42.75)
KROW6: length 99.8
  TOP w0.102: KB2.28 200.04,111.9 199.45,111.31 199.45,103.03 196.22,99.8 196.22,92.34 191.62,87.73 191.62,85.52 189.95,83.86 KB1.28 188.62,83.86 188.42,83.67 188.42,81.7 188.89,81.24 188.89,78.34 187.93,77.38 187.93,70.65 186.19,68.91 186.19,65.92 186.66,65.45 186.66,63.11 AFTP6222.1 185.71,62.17 185.71,58.57 184,56.86 184,53.75 183.33,53.09 183.33,50.55 180.43,47.64 178.93,47.64 178.04,46.75 178.04,44.77 177.09,43.82 v1(177.09,43.08) ; v1(165.2,40.33) 165.66,39.87 165.66,38.9 165.29,38.54 KBC24.60
  BOTTOM w0.102: v1(177.09,43.08) 176.48,43.08 174.59,44.96 168.35,44.96 166.33,42.94 166.33,42.64 166.33,42.36 165.66,41.69 165.66,40.79 v1(165.2,40.33)
KROW7: length 100.1
  TOP w0.102: v1(164.95,39.69) 165.22,39.41 165.22,38.8 164.89,38.47 KBC24.61 ; v1(177.49,42.46) 177.62,42.59 177.62,44.06 178.24,44.68 178.24,46.66 179.02,47.44 180.51,47.44 183.54,50.47 183.54,53 184.2,53.66 184.2,56.77 185.92,58.49 185.92,60.34 AFTP6221.1 186.86,61.28 186.86,65.53 186.39,66 186.39,68.82 188.13,70.57 188.13,77.3 189.09,78.25 189.09,81.32 188.62,81.79 188.62,82.9 188.78,83.06 KB1.29 190.28,83.06 191.82,84.6 191.82,87.65 196.43,92.26 196.43,99.72 199.65,102.94 199.65,110.9 199.85,111.1 KB2.29
  BOTTOM w0.102: v1(164.95,39.69) 165.22,39.69 165.86,40.33 165.86,41.6 166.54,42.27 166.54,42.55 166.54,42.86 168.44,44.76 174.51,44.76 176.81,42.46 v1(177.49,42.46)
L_BKLT_CTRL: length 105.4
  L3 w0.127: v1(46.24,78.74) 46.24,85.64 v1(45.96,85.92)
  L4 w0.127: v1(121,100.53) 120.31,99.83 117.55,99.83 117.33,100.05 115.23,100.05 115.13,100.15 109.64,100.15 109.46,99.97 101.91,99.97 101.62,99.68 100.32,99.68 99.48,98.84 95.2,98.84 94.29,99.74 92.68,99.74 88.81,103.61 77.33,103.61 75.64,101.92 72.51,101.92 69.2,98.62 67.51,98.62 61.03,92.14 53.48,92.14 48.03,86.69 46.73,86.69 v1(45.96,85.92)
  BOTTOM w0.089: CPU1.B8 114.24,93.07 114.64,93.48 114.64,93.88 114.55,93.97 114.55,94.48 114.8,94.73
  BOTTOM w0.14: v1(46.24,78.74) 45.83,79.15 R5206.1 ; 114.8,94.73 116.89,96.82 117.5,96.82 117.92,97.24 117.92,98.62 v2(119.53,100.23) 119.77,100.47 120.95,100.47 v1(121,100.53)
L_BKLT_EN: length 134.6
  TOP w0.102: v1(183.86,28.23) 183.83,28.2 v2(183.18,28.2) R2444.1
  L3 w0.102: v1(132.16,100.99) 131.45,100.28 128.1,100.28 127.96,100.14 127.63,100.14 125.73,98.24 123.26,98.24 122.98,98.52 122.36,98.52 121.43,97.58 120.62,97.58 120.47,97.73 116,97.73 v1(115.84,97.89) ; v1(183.86,28.23) 181.67,30.42 176.6,30.42 175.97,31.06 175.09,31.06 173.37,32.77 173.37,32.98 172.75,33.6 171.55,33.6 170.49,34.67 165.99,34.67 163.87,36.79 162.95,36.79 161.95,37.8 161.95,37.91 151.94,47.92 151.94,50.82 149.47,53.3 149.47,53.62 148.93,54.15 145.93,54.15 144.85,55.23 144.85,56.05 142.88,58.02 142.88,71.14 138.19,75.83 138.19,80.82 v1(136.32,82.69)
  BOTTOM w0.102: CPU1.A9 113.44,94 113.47,94.02 113.47,94.65 113.92,95.1 113.92,95.2 115.85,97.13 115.85,97.89 v1(115.84,97.89) ; v1(132.16,100.99) 132.68,101.52 133.12,101.52 134.12,100.52 135.39,100.52 135.75,100.88 135.75,101.07 136.11,101.43 136.54,101.43 137.46,100.5 137.46,99.05 136.95,98.54 136.95,97.1 137.31,96.74 137.31,94.55 135.66,92.9 135.66,91.05 136.39,90.32 136.39,88.31 136.85,87.85 136.85,83.23 v1(136.32,82.69)
L_BKLT_EN_EC: length 4.6
  TOP w0.102: R2444.2 R2447.1 181.09,27.22 v2(179.8,27.22) 179.27,27.22 179.09,27.04 178.5,27.04 178.36,26.9 KBC24.9
LAN_ENABLE_R_C: length 3.3
  TOP w0.127: v2(35.66,48.85) R3022.1 R3021.2 37.48,48.38 37.34,48.24 Q3001.D
LAN_MDI0N: length 22.8
  BOTTOM w0.102: v2(41.39,55.63) 41.52,55.63 ; 41.52,55.63 41.52,58.11 41.39,58.24 LOM30.2 ; 41.52,55.63 41.52,55.02 39.27,52.77 35.75,52.77 EC3102.2 35.11,52.77 34.7,52.77 34.59,52.88 34.59,54.37 34.29,54.67 34.03,54.67 33.91,54.79 U3101.9 U3101.2 31.98,54.79 31.87,54.68 31.59,54.68 31.27,54.35 31.27,53.71 32.49,52.49 32.49,52.32 32.12,51.95 31.34,51.95 31.2,52.09 31.2,52.53 31.08,52.65 30.17,52.65
LAN_MDI0P: length 22.7
  BOTTOM w0.102: 38.48,52.52 35.75,52.52 EC3101.2 35.11,52.52 34.59,52.52 34.34,52.77 34.34,54.26 34.18,54.42 34.03,54.42 33.91,54.31 U3101.10 U3101.1 31.99,54.31 31.87,54.42 31.7,54.42 31.52,54.25 31.52,53.81 32.74,52.59 32.74,52.21 32.23,51.7 31.35,51.7 31.03,51.38 30.17,51.38 ; 38.48,52.52 v2(38.48,52.39) ; 38.48,52.52 39.37,52.52 41.77,54.92 41.77,58.11 41.79,58.13 LOM30.1
LAN_MDI1N: length 23.1
  BOTTOM w0.102: v2(36.58,55.15) 36.46,55.15 ; 36.46,55.15 36.46,54.25 37.05,53.66 38.32,53.66 40.26,55.59 40.26,58.17 40.19,58.23 LOM30.5 ; 36.46,55.15 36.46,56.35 35.95,56.86 35.55,56.86 EC3104.2 34.86,56.76 34.59,56.76 34.03,56.2 33.91,56.2 33.8,56.31 U3101.6 U3101.5 31.96,56.31 31.85,56.2 31.67,56.2 31.54,56.33 31.54,56.63 32.89,57.98 32.89,59.32 32.46,59.76 31.75,59.76 31.52,59.53 31.32,59.53 31.18,59.66 31.18,60.09 31,60.27 30.17,60.27
LAN_MDI1P: length 23.1
  BOTTOM w0.102: 40.51,56.99 40.51,58.11 40.59,58.19 LOM30.4 ; 40.51,56.99 v2(40.64,56.99) ; 40.51,56.99 40.51,55.49 38.43,53.4 36.95,53.4 36.2,54.15 36.2,54.36 36.2,56.24 35.84,56.6 35.59,56.6 EC3103.2 35.01,56.51 34.69,56.51 34.14,55.95 33.91,55.95 33.79,55.83 U3101.7 U3101.4 31.97,55.83 31.85,55.95 31.57,55.95 31.29,56.22 31.29,56.74 32.64,58.09 32.64,59.22 32.35,59.5 31.86,59.5 31.63,59.27 31.16,59.27 30.88,59 30.17,59
LAN_MDI2N: length 21
  TOP w0.102: v2(36.63,55.53) 36.63,55.4 ; 36.63,55.4 37.15,55.4 v1(37.44,55.7) ; 36.63,55.4 36.52,55.4 36.19,55.07 36.19,52.97 36.02,52.8 35.72,52.8 EC3106.2 35.14,52.8 34.69,52.8 34.62,52.87 34.62,54.37 34.31,54.68 34.03,54.68 33.91,54.79 U3102.2 U3102.9 31.94,54.79 31.8,54.65 31.54,54.65 31.27,54.38 31.27,53.7 31.95,53.01 31.95,52.16 31.67,51.87 31.25,51.87 31.18,51.93 31.18,52.54 31.08,52.65 30.17,52.65
  BOTTOM w0.102: 38.2,55.4 37.74,55.4 v1(37.44,55.7) ; 38.2,55.4 v2(38.2,55.52) ; 38.2,55.4 38.42,55.4 39.14,56.12 39.14,57.39 39.47,57.72 39.47,58.16 39.39,58.24 LOM30.7
LAN_MDI2P: length 21
  TOP w0.102: v2(32.33,52.48) 32.2,52.48 ; 32.2,52.48 32.2,53.12 31.52,53.8 31.52,54.27 31.65,54.4 31.8,54.4 31.88,54.31 U3102.10 U3102.1 33.91,54.31 34.03,54.43 34.21,54.43 34.36,54.27 34.36,52.77 34.59,52.54 35.09,52.54 EC3105.2 35.77,52.54 36.13,52.54 36.44,52.86 36.44,54.97 36.62,55.15 37.27,55.15 37.44,54.98 v1(37.44,54.8) ; 32.2,52.48 32.2,52.05 31.77,51.62 31.28,51.62 31.04,51.38 30.17,51.38
  BOTTOM w0.102: v1(37.44,54.8) 37.78,55.14 38.52,55.14 39.4,56.02 39.4,56.19 ; 39.4,56.19 v2(39.53,56.19) ; 39.4,56.19 39.4,57.29 39.73,57.61 39.73,58.13 39.79,58.2 LOM30.6
LAN_MDI3N: length 17.5
  TOP w0.102: 32.86,58.2 32.86,58.03 31.49,56.66 31.49,56.3 31.6,56.2 31.8,56.2 31.91,56.31 U3102.6 U3102.5 33.91,56.31 34.03,56.2 34.18,56.2 34.29,56.3 34.29,56.56 34.57,56.84 34.94,56.84 EC3108.2 35.57,56.84 35.75,56.84 36.06,57.15 36.44,57.15 v1(36.79,57.51) ; 32.86,58.2 32.86,58.83 31.93,59.76 31.29,59.76 31.18,59.86 31.18,60.16 31.08,60.27 30.17,60.27 ; 32.86,58.2 v2(32.99,58.2)
  BOTTOM w0.102: LOM30.10 37.88,59.82 37.43,59.37 37.43,58.56 37.84,58.14 37.84,57.51 37.53,57.19 37.11,57.19 v1(36.79,57.51)
LAN_MDI3P: length 17.5
  TOP w0.102: v1(36.79,56.61) 36.79,56.77 36.68,56.89 36.17,56.89 35.85,56.58 35.57,56.58 EC3107.2 34.93,56.59 34.67,56.59 34.54,56.46 34.54,56.2 34.29,55.95 34.03,55.95 33.91,55.83 U3102.4 U3102.7 31.84,55.83 31.72,55.95 31.49,55.95 31.24,56.2 31.24,56.77 32.61,58.13 32.61,58.72 31.82,59.5 31.29,59.5 31.18,59.4 31.18,59.1 31.08,59 30.17,59
  BOTTOM w0.102: 37.86,57.16 38.1,57.4 38.1,58.24 37.68,58.66 37.68,59.26 37.84,59.42 LOM30.9 ; 37.86,57.16 v2(37.95,57.07) ; 37.86,57.16 37.64,56.94 37.12,56.94 v1(36.79,56.61)
LAN_TXN_C_PCH_RXN4: length 3.5
  BOTTOM w0.127: C3016.1 39.23,65.79 39.23,65.15 ; 39.23,65.15 v2(39.36,65.15) ; 39.23,65.15 39.23,63.63 39.39,63.47 LOM30.18
LAN_TXP_C_PCH_RXP4: length 3.4
  BOTTOM w0.127: 38.99,64.03 38.99,65.69 C3014.1 ; 38.99,64.03 LOM30.17 ; 38.99,64.03 v2(38.86,64.03)
LANXIN: length 8.7
  BOTTOM w0.14: LOM30.28 43.46,61.02 43.68,61.23 44.19,61.23 45.13,60.3 C3001.1 45.68,60.3 45.98,60 47.51,60 X3001.1 v2(50.23,60.9)
LANXOUT: length 5.4
  BOTTOM w0.14: X3001.3 46.89,58.71 46.2,59.41 C3011.1 45,59.41 44.55,59.86 44.55,59.96 v2(44.19,60.32) 43.89,60.62 LOM30.29
LCD_BRIGHTNESS: length 6.8
  TOP w0.14: LCD1.20 37.45,83.03 37.22,82.8 37.22,81.88 36.64,81.3 36.64,80.78 36.28,80.42 AFTP5203.1 36.68,79.32 36.79,79.32 v1(37.11,79)
  BOTTOM w0.14: v1(37.11,79) 37.18,79 37.77,78.41 RN5201.2
LCD_TST: length 262.3
  TOP w0.102: v1(183.17,37.68) 182.98,37.49 R2417.1 ; v1(61.44,11.04) 61.44,9.21 69.57,1.09 82.59,1.09 82.61,1.07 90.12,1.07 90.51,1.46 163.28,1.46 164.92,3.1 v1(164.92,4.26)
  L3 w0.102: v1(61.44,11.04) 57.88,11.04 50.14,18.79 50.14,19.44 43.13,26.45 41.95,26.45 41.95,26.45 38.6,26.45 37.59,27.46 37.59,34.81 36.51,35.9 35.56,35.9 35.15,35.49 30.19,35.49 28.8,36.87 28.8,42.83 30.13,44.16 v1(30.13,47.67)
  L4 w0.102: v1(30.13,47.67) 30.59,47.67 31.13,48.21 31.13,49.32 32.32,50.5 32.32,53.09 32.93,53.7 32.93,55.93 32.24,56.62 32.24,58.55 30.81,59.98 30.81,65.88 30.43,66.27 30.43,69.28 29.19,70.52 29.19,71.95 33.94,76.7 39.42,76.7 v1(39.49,76.77) ; v1(164.92,4.26) 167.82,7.15 179.47,7.15 182.46,10.14 182.46,20.59 183.51,21.65 183.51,24.25 183.69,24.43 183.69,26.66 183.41,26.94 183.41,30.57 184.3,31.46 184.3,32.08 183.49,32.89 183.49,37.36 v1(183.17,37.68)
  BOTTOM w0.102: RN5201.8 39.92,77.76 v2(40.34,77.35) 40.34,76.98 40.13,76.77 v1(39.49,76.77)
LCD_TST_C: length 13.7
  TOP w0.102: LCD1.10 42.45,81.89 43.91,80.43 AFTP5207.1 43.91,78.99 v1(43.87,78.95)
  L4 w0.102: v1(43.87,78.95) 43.76,79.06 38.86,79.06 38.04,78.25 37.28,78.25 v1(37.16,78.37)
  BOTTOM w0.102: RN5201.1 37.7,77.76 37.16,78.3 v1(37.16,78.37)
LCD_TST_EN: length 263.5
  TOP w0.102: KBC24.28 177.76,34.62 178.48,34.62 178.55,34.69 178.93,34.69 178.97,34.74 179.04,34.74 181,36.69 v2(181.48,36.69) 181.57,36.61 R2417.2 182.53,36.61 183.13,37.2 184.4,37.2 184.84,36.76 188.32,36.76 188.55,36.53 188.55,35.52 189.04,35.03 189.04,34.19 v1(188.37,33.51) ; D5201.2 58.07,72.96 v1(58.42,72.61)
  L4 w0.102: v1(188.37,33.51) 188.47,33.41 188.47,19.65 187.65,18.84 187.65,17.21 186.64,16.2 186.64,13.13 178.6,5.09 178.6,5.08 176.17,2.65 132.8,2.65 131.92,3.53 130.02,3.53 129.98,3.5 129.88,3.5 129.07,2.68 110.57,2.68 109.45,3.8 106.29,3.8 105.92,3.44 77.47,3.44 70.69,10.23 54.85,10.23 54.53,10.55 54.17,10.55 53.86,10.23 49.73,10.23 47.32,12.64 47.32,16.84 36.95,27.2 36.95,40.87 38.95,42.87 39.43,42.87 41.38,44.83 41.69,44.83 45.8,48.94 46.12,48.94 55.53,58.34 55.53,68.61 58.62,71.7 58.62,72.16 58.42,72.37 v1(58.42,72.61)
LCDVDD:
  vias: v2(47.51,75.81)
LCDVDD_EN: length 6.2
  TOP w0.102: D5201.3 54.2,76.29 53.7,76.8 v2(53.24,76.8) R5202.2 50.74,75.82 U5201.1
LDO1_CAP: length 5.1
  TOP w0.203: 31.15,12.72 31.16,12.72 31.61,12.26 31.62,12.26 31.74,12.14 HDA27.27
  TOP w0.254: 31.15,12.72 31.1,12.76 v1(30.9,12.76) 30.53,12.76 C2702.2
  BOTTOM w0.254: R2711.2 29.94,13.64 29.94,12.92 v2(29.97,12.9) 30.05,12.81 30.85,12.81 v1(30.9,12.76)
LDO2_CAP: length 5.7
  TOP w0.203: 33.11,6.1 33.29,6.28 33.46,6.28 34.23,7.05 HDA27.39
  TOP w0.254: C2712.2 30.8,4.67 31.81,5.67 v2(32.23,5.67) 32.68,5.67 33.11,6.1
LDO3_CAP: length 3
  TOP w0.203: 39.32,10.94 HDA27.7
  TOP w0.254: C2718.1 40.81,11.52 40.29,10.99 39.37,10.99 39.32,10.94
LDO_EN: length 4
  TOP w0.102: v1(16.88,76.23) 17.01,76.36 U5502.21
  BOTTOM w0.102: R5512.2 16.24,76.87 v1(16.88,76.23) 16.74,76.09 R5502.1 15.94,75.57 v2(15.72,75.35)
LED0: length 1.8
  BOTTOM w0.102: LOM30.27 43.13,61.42 43.57,61.85 TP3003.1
LED1: length 7.6
  BOTTOM w0.102: TP3002.1 49.41,62.21 43.47,62.21 43.08,61.82 LOM30.26
LED2: length 6.5
  BOTTOM w0.102: LOM30.25 43.04,62.22 43.24,62.43 47.91,62.43 TP3001.1
LID_CLOSE#: length 281.5
  TOP w0.102: v1(176.17,31.48) 176.17,30.31 176.38,30.1 KBC24.17 ; v1(10.16,74.77) 10.19,74.73 R6401.1 C6401.1 9.96,73.85 9.47,74.34 3.29,74.34 1.68,72.73 LIDSW1.3 ; D2401.K 186.74,24.94 186.26,25.43 186.26,26.48 186.54,26.76 187.55,26.76 D2402.K 187.55,27.22 186.54,27.22 186.26,27.5 186.26,28.77 v2(186,29.02) v1(184.99,29.02)
  L3 w0.102: v1(10.16,74.77) 14.49,74.77 18.36,70.9 24.24,70.9 27.12,68.01 27.12,64.75 31.22,60.65 31.22,59.87 30.72,59.37 30.72,57.45 32.29,55.88 32.29,50.95 31.95,50.61 31.95,45.41 32.22,45.14 32.22,43.9 29.28,40.96 29.28,37.07 30.39,35.97 34.95,35.97 35.36,36.38 35.76,36.38 36.71,36.38 38.08,35.01 38.08,28.34 v1(38.73,27.69) ; v1(176.17,31.48) 176.85,30.8 183.21,30.8 v1(184.99,29.02)
  L4 w0.102: v1(176.17,31.48) 176.17,29.71 178.07,27.8 178.07,19.95 177.17,19.05 177.17,14.48 170.05,7.36 167.16,7.36 164.04,4.24 154.05,4.24 152.96,3.16 147.07,3.16 145.29,4.94 138.14,4.94 137.53,5.56 131.43,5.56 130.64,4.77 129.64,4.77 129.51,4.64 129.41,4.64 128.59,3.82 111.15,3.82 110.03,4.95 105.81,4.95 105.45,4.58 78.41,4.58 70.67,12.32 66.15,12.32 63.94,14.53 50.96,14.53 38.73,26.76 v1(38.73,27.69)
  BOTTOM w0.102: R2421.1 174.42,31.52 174.83,31.11 175.79,31.11 v1(176.17,31.48)
LINE1-L_C: length 2.4
  TOP w0.254: C2907.2 28.84,16.83 v2(27.73,16.83) R2922.1
LINE1-L_R: length 2.4
  TOP w0.254: R2921.1 27.63,18.55 v2(27.83,18.34) 27.87,18.31 C2908.2
LINE1_L: length 5.5
  TOP w0.203: HDA27.22 34.23,14.27 33.96,14.55 33.89,14.55
  TOP w0.254: C2907.1 30.61,17 v2(32,15.61) 33.07,14.55 33.89,14.55
LINE1_R: length 7
  TOP w0.203: 33.4,15.05 33.96,15.05 33.96,15.05 34.63,14.38 HDA27.21
  TOP w0.254: C2908.1 30.94,18.31 v2(31.35,17.89) 31.63,17.61 31.63,16.82 33.4,15.05
LINE1_VREFO_L: length 3.5
  TOP w0.203: R2912.1 29.7,11.15 30.25,10.6 30.56,10.6 v2(30.64,10.52) 30.66,10.54 HDA27.31
LINE1_VREFO_R: length 5.8
  TOP w0.203: HDA27.30 31.14,10.94
  TOP w0.254: R2913.1 28.21,12.22 v2(28.31,12.11) 28.73,11.69 29.84,11.69 30.45,11.08 31,11.08 31.14,10.94
LOM_TCT: length 19.5
  TOP w0.508: v1(30.85,55.02) 30.42,55.02 30.17,54.77 30.17,53.92
  TOP w0.635: 30.17,57.73 31.08,57.73 v1(31.69,58.33)
  L4 w0.508: v1(31.69,58.33) 31.69,56.55 30.85,55.71 v1(30.85,55.02) 31.65,54.22 31.65,50.89 30.62,49.86 30.62,48.45 v1(30.5,48.34)
  BOTTOM w0.508: 30.17,53.92 30.17,54.68 30.51,55.02 v1(30.85,55.02) ; C3106.1 32.01,48.4 v2(31.19,48.4) 30.57,48.4 v1(30.5,48.34)
  BOTTOM w0.635: v1(31.69,58.33) 31.08,57.73 30.17,57.73
LPC_AD0: length 122.6
  TOP w0.14: KBC24.126 175.29,22.91 175.33,22.95 175.33,24.03 175.07,24.29 v1(175.07,24.29) ; RN6501.1 162.99,14.2 162.99,16.95 v1(162.96,16.98) 162.03,17.9 161.22,17.9 160.19,18.93 157.89,18.93 156.97,18.02 156.97,17.86 154.69,15.58 151.22,15.58 150.66,16.14 v2(150.66,19.62) 150.66,20.06 v1(150.24,20.48)
  L3 w0.127: v1(115.19,52.84) 115.27,52.75 115.27,50.02 115.29,50 115.29,49.64 115.27,49.62 115.27,48 115.25,47.98 115.25,44.95 v1(115.42,44.79)
  BOTTOM w0.14: v1(115.19,52.84) 115.49,53.14 115.49,53.7 116.48,54.69 116.48,56.46 116.77,56.75 116.77,58.25 114.45,60.57 114.45,64.94 113.3,66.09 RN1806.5 ; v1(175.07,24.29) 175.07,24.29 175.15,24.21 175.15,22.93 175.16,22.93 175.16,21.8 173.86,20.51 172.31,20.51 171.55,19.75 167.68,19.75 167.47,19.96 166.67,19.96 163.69,16.98 v1(162.96,16.98) ; v1(115.42,44.79) 115.82,44.38 121.36,44.38 123.61,46.63 141.62,46.63 143.25,45.01 143.25,40.92 143.9,40.27 143.9,36 145.98,33.92 145.98,31.27 145.98,30.93 147.64,29.27 147.64,23.89 150.24,21.29 v1(150.24,20.48)
LPC_AD1: length 123.8
  TOP w0.14: v1(149.75,22.55) 149.63,22.43 149.63,19.45 150.24,18.84 150.24,15.97 151.04,15.16 154.86,15.16 v2(157.81,18.12) 158.21,18.52 160.02,18.52 161.05,17.48 161.48,17.48 161.93,17.03 v1(161.93,17) 161.93,16.71 162.35,16.28 RN6501.2 ; KBC24.127 175.69,22.93 176.02,23.26 v1(176.02,23.29)
  L3 w0.127: v1(114.68,53.77) 115.03,53.77 115.67,53.13 115.67,45.21 v1(116.05,44.83)
  BOTTOM w0.14: v1(161.93,17) 161.96,16.97 161.96,16.75 162.6,16.11 164.01,16.11 166.07,18.17 167.58,18.17 168.32,18.91 172.37,18.91 172.62,18.66 173.92,18.66 175.36,20.1 175.36,20.65 175.99,21.29 175.99,23.23 176.02,23.26 v1(176.02,23.29) ; v1(116.05,44.83) 120.9,44.83 123.12,47.05 142.01,47.05 143.67,45.39 143.67,41.13 144.32,40.48 144.32,36.17 146.39,34.09 146.39,31.1 148.05,29.44 148.05,24.25 v1(149.75,22.55) ; RN1806.7 112.15,64.47 113.56,63.06 113.56,60.23 115.6,58.19 115.6,57.49 115.14,57.03 115.14,55.3 115.24,55.21 115.24,54.33 v1(114.68,53.77)
LPC_AD2: length 126.6
  TOP w0.14: KBC24.128 176.33,22.15 176.57,22.4 176.57,23.44 176.19,23.83 175.94,23.83 v1(175.86,23.91) ; RN6501.3 161.85,16.16 161.29,16.73 v1(161.29,17.03) 160.91,17.03 159.85,18.1 158.39,18.1 v2(156.95,16.66) 156.95,15.3 156.4,14.74 150.87,14.74 149.66,15.95 v1(149.66,18.58)
  L3 w0.127: v1(114.68,55.49) 113.85,54.67 113.85,48 114.11,47.74 114.11,43.74 v1(114.38,43.47)
  BOTTOM w0.14: v1(161.29,17.03) 161.71,17.45 162.12,17.45 162.5,17.06 162.5,16.79 162.77,16.53 163.84,16.53 165.93,18.62 167.43,18.62 168.15,19.33 172.54,19.33 172.8,19.08 173.7,19.08 174.93,20.31 174.93,20.98 175.58,21.63 175.58,23.1 175.57,23.11 175.57,23.6 175.86,23.89 v1(175.86,23.91) ; v1(149.66,18.58) 146.38,21.86 146.38,28.67 144.67,30.37 144.67,31.14 144.67,31.14 144.67,33.45 142.64,35.48 142.64,39.69 141.97,40.36 141.97,44.41 141.01,45.38 124.41,45.38 122.07,43.04 114.71,43.04 114.38,43.36 v1(114.38,43.47) ; RN1806.8 111.5,64.52 113.12,62.9 113.12,59.95 114.7,58.37 114.7,55.49 114.69,55.49 v1(114.68,55.49)
LPC_AD3: length 125.7
  TOP w0.14: v1(149.18,20.36) 149.21,20.33 149.21,15.81 150.7,14.33 156.6,14.33 v2(157.25,14.98) 157.45,15.18 157.45,16.54 158.58,17.68 159.6,17.68 160.24,17.04 v1(160.24,16.89) 161.2,15.92 RN6501.4 ; KBC24.1 v1(177.64,23.19)
  L3 w0.127: v1(115.59,55.49) 115.59,54.09 116.07,53.61 116.07,45.94 116.54,45.48 116.54,43.71 v1(116.33,43.5)
  BOTTOM w0.14: v1(149.18,20.36) 146.8,22.74 146.8,28.84 145.09,30.55 145.09,30.97 145.09,30.97 145.09,33.62 143.06,35.65 143.06,39.86 142.39,40.53 142.39,44.64 141.24,45.79 124.09,45.79 121.8,43.5 v1(116.33,43.5) ; v1(115.59,55.49) 115.63,55.53 115.63,56.21 116.35,56.93 116.35,58.07 114.02,60.4 114.02,63.19 112.65,64.56 RN1806.6 ; v1(160.24,16.89) 160.27,16.85 160.27,16.83 161.82,15.27 164.42,15.27 166.28,17.13 168.88,17.13 169.51,17.77 170.3,17.77 170.53,17.54 173.99,17.54 175.91,19.46 176.42,19.46 176.83,19.87 176.83,22.38 v1(177.64,23.19)
LPC_FRAME#: length 31.5
  TOP w0.14: v1(175.74,25.32) 176.19,25.32 176.68,24.83 176.68,24.71 176.9,24.5 KBC24.3 ; R6501.1 160.22,14 R1801.1 160.05,14.84 159.28,15.61 v2(159.28,15.74) 159.2,15.82 159.2,16.63 v1(159.04,16.79)
  BOTTOM w0.14: v1(159.04,16.79) 159.14,16.79 159.69,17.34 160.42,17.34 160.84,16.92 160.84,16.85 161.99,15.69 164.18,15.69 166.04,17.55 168.7,17.55 169.64,18.49 172.2,18.49 172.45,18.24 174.1,18.24 175.78,19.92 175.78,20.48 176.41,21.11 176.41,22.55 176.68,22.82 176.68,23.81 176.7,23.83 176.7,24.2 175.74,25.16 v1(175.74,25.32)
LPC_FRAME#_DEBUG: length 4.9
  TOP w0.14: v1(159.72,11.43) 159.51,11.65 v2(159.51,12.34) 159.51,12.39 R6501.2
  BOTTOM w0.14: DB1.6 159.72,11.69 159.72,11.69 v1(159.72,11.43)
LPC_LAD0_PCH: length 7.9
  BOTTOM w0.089: CPU1.AU14 111.17,73.04 111.5,73.37 112.05,73.37 112.21,73.53 112.76,73.53 112.91,73.39 112.91,71.46 112.99,71.39 112.99,70.76 113.2,70.55
  BOTTOM w0.14: 113.2,70.55 113.39,70.35 113.39,68.62 113.3,68.53 RN1806.4
LPC_LAD0_R: length 6.2
  TOP w0.14: RN6501.8 163.02,13.23 163.8,13.23 v2(163.95,13.07) 163.95,11.79 v1(163.58,11.42)
  BOTTOM w0.14: DB1.2 164.72,13.35 163.58,12.2 v1(163.58,11.42)
LPC_LAD1_PCH: length 4.2
  BOTTOM w0.089: 112.09,70.17 112.09,71.42 CPU1.AW12
  BOTTOM w0.14: 112.09,70.17 111.94,70.02 111.94,68.83 112.15,68.61 RN1806.2
LPC_LAD1_R: length 5.2
  TOP w0.14: v1(162.87,11.43) 162.99,11.54 v2(162.99,12.06) 162.99,12.13 162.35,12.77 RN6501.7
  BOTTOM w0.14: DB1.3 163.47,13.29 162.87,12.69 v1(162.87,11.43)
LPC_LAD2_PCH: length 3.4
  BOTTOM w0.14: RN1806.1 111.5,67.84 111.5,68.49 111.45,68.55 v2(111.45,69.21) 111.45,70.2 111.77,70.52 CPU1.AY12
LPC_LAD2_R: length 4.8
  TOP w0.14: RN6501.6 161.85,12.77 161.77,12.69 v2(161.77,12.13) 161.77,11.89 v1(162.22,11.43)
  BOTTOM w0.14: v1(162.22,11.43) 162.22,11.44 DB1.4
LPC_LAD3_PCH: length 4.3
  BOTTOM w0.089: CPU1.AW11 112.73,71.53 112.73,71.39 112.81,71.31 112.81,70.62 113.12,70.3 113.12,69.97 113.1,69.94 112.78,69.63
  BOTTOM w0.14: RN1806.3 112.65,69.19 v2(112.67,69.21) 112.67,69.52 112.78,69.63
LPC_LAD3_R: length 5.8
  TOP w0.14: v1(161.5,11.44) 160.78,11.44 v2(160.7,11.52) 160.65,11.57 160.65,12.66 RN6501.5
  BOTTOM w0.14: DB1.5 160.97,13.12 161.5,12.59 v1(161.5,11.44)
LPC_LFRAME#_PCH: length 108.2
  TOP w0.14: v1(149.18,21.45) 148.73,21 148.73,15.7 150.52,13.91 156.9,13.91 157.87,14.87 157.87,16.31 v2(158.19,16.63) 158.81,17.26 159.31,17.26 159.79,16.79 159.79,16.17 R1801.2
  L3 w0.127: v1(115.09,43.49) 115.09,44.42 114.74,44.77 114.74,47.65 114.23,48.16 114.23,54.18 v1(114.7,54.64)
  BOTTOM w0.089: 111.09,69.02 111.09,70.47 111.49,70.87 111.49,72.14 CPU1.AV12
  BOTTOM w0.14: v1(149.18,21.45) 147.22,23.41 147.22,29.09 145.51,30.8 145.51,33.79 144.28,35.02 143.48,35.82 143.48,40.05 142.81,40.72 142.81,44.86 141.45,46.21 123.92,46.21 121.66,43.95 115.56,43.95 v1(115.09,43.49) ; 111.09,69.02 111.09,68.48 110.97,68.35 110.97,64.46 112.63,62.8 112.63,59.82 114.24,58.21 114.24,56.55 114.2,56.5 114.2,55.19 114.7,54.68 v1(114.7,54.64)
LPSS_GSPI0_MOSI_BBS0_R: length 13.2
  TOP w0.102: R2012.2 111,82.06 111.36,82.42 111.36,82.89 v2(111.93,83.47) 112.7,84.24 113.04,84.24 113.31,84.5 113.31,85.31 113.5,85.5 115.41,85.5 116.29,86.38 116.81,86.38 117.25,86.82 v1(117.25,87.63)
  BOTTOM w0.102: CPU1.L8 114.47,87.38 114.78,87.68 117.2,87.68 v1(117.25,87.63)
LPSS_SDIO_D0_CMNHDR: length 9.3
  BOTTOM w0.089: CPU1.D3 117.93,91.34 118.37,91.34 118.56,91.53 119.11,91.53 119.31,91.72 119.55,91.72 119.89,92.06 119.89,92.22
  BOTTOM w0.102: R2011.2 123.21,97.17 120.09,94.05 120.09,92.43 119.89,92.22
M_A_A0: length 58.5
  TOP w0.216: v2(97.41,72.99) 97.36,72.99 97.11,72.74 v1(96.9,72.74)
  L4 w0.089: v1(96.9,72.74) 96.46,72.3 96.46,65.04 96.81,64.69 96.81,64.04
  L4 w0.216: v1(81.75,24.18) 81.8,24.18 82.26,24.64 82.26,26.34 81.42,27.18 81.42,30.5 81.67,30.75 81.67,33.07 82.23,33.63 82.23,34.54 93.16,45.46 93.16,48.18 96.81,51.84 96.81,64.04
  BOTTOM w0.216: v1(96.9,72.74) 97.19,73.04 CPU1.AU36 ; DM1.98 81.75,22.72 81.75,24.18 v1(81.75,24.18)
M_A_A1: length 60.1
  TOP w0.216: v1(97.05,69.44) 97.11,69.44 v2(97.56,69.89)
  L4 w0.089: 97.38,64.36 97.38,64.65 96.64,65.4 96.64,69.02 v1(97.05,69.44)
  L4 w0.216: 97.38,64.36 97.38,51.58 96.67,50.87 96.67,50.56 97.31,49.92 97.31,49.74 96.88,49.31 96.7,49.31 96.05,49.95 95.75,49.95 95.44,49.64 95.44,49.34 96.43,48.34 96.43,48.04 96.12,47.73 95.82,47.73 94.83,48.72 94.52,48.72 94.22,48.42 94.22,48.11 95.21,47.12 95.21,46.81 94.9,46.51 94.59,46.51 94.34,46.76 94.05,46.76 93.73,46.44 93.73,46.15 93.98,45.89 93.98,45.48 82.8,34.3 82.8,33.39 82.79,33.38 82.79,33.32 82.25,32.79 82.25,32.05 82.54,31.76 82.54,29.24 82.12,28.82 v1(82.05,28.82)
  BOTTOM w0.203: v1(97.05,69.44) 96.76,69.44 96.44,69.76 96.44,71.06 CPU1.AY37
  BOTTOM w0.216: DM1.97 81.45,29.33 81.95,28.82 v1(82.05,28.82)
M_A_A2: length 60.5
  TOP w0.216: v1(95.79,73.82) v2(95.79,74.45)
  L4 w0.089: v1(95.79,73.82) 95.79,73.74 95.9,73.62 95.9,65.8 95.1,65 95.1,64.81
  L4 w0.216: v1(81.75,25.45) 81.69,25.45 81.23,25.92 81.23,26.36 79.56,28.02 79.56,31.88 79.55,31.89 79.55,34.28 87.16,41.89 87.16,44.61 95.1,52.55 95.1,64.81
  BOTTOM w0.216: CPU1.AR38 96.16,74.2 v1(95.79,73.82) ; DM1.96 81.15,25.11 81.49,25.45 v1(81.75,25.45)
M_A_A3: length 61.4
  TOP w0.216: v1(80.85,29.46) v2(80.85,30.09)
  L4 w0.089: v1(96.76,74.66) 97.17,74.26 97.17,73.58 96.26,72.67 96.26,64.42 96.24,64.4
  L4 w0.216: v1(80.85,29.46) 80.85,31.65 81.1,31.9 81.1,34.22 90.31,43.42 90.31,43.76 89.39,44.67 89.39,44.96 89.72,45.29 90.01,45.29 90.92,44.37 91.23,44.37 91.53,44.68 91.53,44.98 90.49,46.02 90.49,46.33 90.8,46.64 91.11,46.64 91.94,45.8 92.23,45.8 92.56,46.12 92.56,46.41 91.72,47.25 91.72,47.55 96.24,52.07 96.24,64.4
  BOTTOM w0.216: CPU1.AP36 96.95,74.85 v1(96.76,74.66) ; DM1.95 v1(80.85,29.46)
M_A_A4: length 59.7
  TOP w0.216: v1(80.55,24.82) 80.41,24.96 80.26,24.96 v2(80.08,25.14)
  L4 w0.089: 94.53,64.81 94.53,64.94 95.72,66.14 95.72,72.34 v1(95.32,72.74)
  L4 w0.216: 94.53,64.81 94.53,52.78 86.59,44.85 86.59,42.13 78.98,34.52 78.98,31.65 78.99,31.64 78.99,27.78 79.81,26.96 79.81,24.96 79.96,24.82 v1(80.55,24.82)
  BOTTOM w0.216: CPU1.AU39 95.62,73.04 v1(95.32,72.74) ; v1(80.55,24.82) 80.53,24.8 80.3,24.8 79.95,24.45 DM1.92
M_A_A5: length 60
  TOP w0.216: v1(80.85,28.19) 80.67,28.19 v2(80.36,27.88)
  L4 w0.089: 95.67,64.81 95.67,65 96.08,65.41 96.08,72.89 96.77,73.58 v1(96.77,74.01)
  L4 w0.216: v1(80.85,28.19) 80.79,28.19 80.28,28.7 80.28,31.89 80.53,32.14 80.53,34.45 88.17,42.1 88.17,42.41 87.73,42.85 87.73,43.14 88.06,43.46 88.34,43.46 88.78,43.02 89.09,43.02 89.4,43.33 89.4,43.63 88.35,44.68 88.35,44.99 95.67,52.31 95.67,64.81
  BOTTOM w0.216: v1(80.85,28.19) 80.58,28.19 79.65,29.12 DM1.91 ; CPU1.AR36 96.95,74.2 v1(96.77,74.01)
M_A_A6: length 60
  TOP w0.216: v1(78.75,24.82) 78.6,24.82 v2(78.28,25.14)
  L4 w0.089: v1(95.32,69.45) 95.55,69.23 95.55,66.58 93.95,64.99 93.95,64.81
  L4 w0.216: v1(78.75,24.82) 79.1,24.82 79.24,24.96 79.24,26.7 79.02,26.92 78.66,26.92 78.42,27.15 78.42,31.4 78.41,31.41 78.41,31.67 78.24,31.83 78,31.83 77.74,32.1 77.74,33.02 77.95,33.23 78.18,33.23 78.41,33.46 78.41,34.76 86.02,42.36 86.02,45.08 93.95,53.02 93.95,64.81
  BOTTOM w0.089: CPU1.AV40 94.61,72.1 94.61,70.16 v1(95.32,69.45)
  BOTTOM w0.216: v1(78.75,24.82) 78.81,24.82 79.35,24.27 DM1.90
M_A_A7: length 59.7
  TOP w0.216: v2(79.27,26.31) 79.14,26.31 78.92,26.09 v1(78.75,26.09)
  L4 w0.089: 92.24,64.81 92.24,65.16 94.56,67.47 94.56,70.67 v1(95.32,71.43)
  L4 w0.216: 92.24,64.81 92.24,53.73 79.02,40.51 79.02,37.79 75.59,34.37 75.59,31.8 76.69,30.71 76.69,28.02 78.63,26.09 v1(78.75,26.09)
  BOTTOM w0.216: CPU1.AW39 95.62,71.74 95.52,71.63 95.51,71.63 95.33,71.44 95.33,71.43 v1(95.32,71.43) ; v1(78.75,26.09) 78.69,26.09 78.15,25.54 DM1.86
M_A_A8: length 59.6
  TOP w0.216: v1(77.85,28.19) 78.38,28.19 v2(78.43,28.14)
  L4 w0.089: v1(95.32,70.74) 94.74,70.16 94.74,67.04 92.81,65.12 92.81,64.81
  L4 w0.216: v1(77.85,28.19) 77.79,28.19 77.28,28.7 77.28,30.93 76.17,32.04 76.17,34.13 79.92,37.88 79.92,38.22 79.59,38.55 79.59,38.83 79.92,39.16 80.2,39.16 80.53,38.83 80.83,38.83 81.14,39.14 81.14,39.44 80.1,40.48 80.1,40.79 80.41,41.09 80.72,41.09 81.19,40.62 81.48,40.62 81.81,40.94 81.81,41.23 81.33,41.71 81.33,42.01 92.81,53.49 92.81,64.81
  BOTTOM w0.216: v1(95.32,70.74) 95.66,71.09 CPU1.AY39 ; v1(77.85,28.19) 78.2,28.19 79.05,29.04 DM1.89
M_A_A9: length 61
  TOP w0.216: v1(77.85,29.46) v2(77.85,30.09)
  L4 w0.089: v1(95.14,68.13) 95.14,66.84 93.38,65.08 93.38,64.81
  L4 w0.216: v1(77.85,29.46) 77.85,31.16 77.16,31.85 77.16,34.32 82.16,39.32 82.16,39.69 81.93,39.92 81.93,40.21 82.26,40.53 82.55,40.53 82.78,40.3 83.08,40.3 83.39,40.61 83.39,40.92 82.37,41.94 82.37,42.24 82.67,42.55 82.98,42.55 84,41.53 84.31,41.53 84.61,41.84 84.61,42.14 83.59,43.16 83.59,43.47 83.9,43.77 84.2,43.77 84.81,43.17 85.09,43.17 85.42,43.5 85.42,43.79 84.82,44.39 84.82,44.69 93.38,53.26 93.38,64.81
  BOTTOM w0.089: v1(95.14,68.13) 95.12,68.13 94.43,68.82 94.43,72.43 94.85,72.84 CPU1.AU40
  BOTTOM w0.216: DM1.85 v1(77.85,29.46)
M_A_A10: length 60
  TOP w0.216: v1(84.81,29.46) v2(84.81,30.09)
  L4 w0.091: 99.09,66.59 98.07,67.61 98.07,70.57 98.07,70.57 98.07,70.91 98.07,70.91 98.07,71.75 97.36,72.46 97.36,74.13 v1(97.76,74.52)
  L4 w0.216: 99.09,66.59 99.5,66.18 99.5,46.85 94.25,41.59 94.25,41.29 94.77,40.76 94.77,40.46 94.46,40.15 94.16,40.15 93.63,40.67 93.33,40.67 93.02,40.37 93.02,40.06 93.54,39.54 93.54,39.23 93.24,38.92 92.93,38.92 92.41,39.45 92.1,39.45 91.79,39.14 91.79,38.84 92.15,38.48 92.15,38.19 91.82,37.87 91.54,37.87 91.18,38.22 90.88,38.22 85.13,32.48 85.13,31.81 84.94,31.62 84.94,29.59 v1(84.81,29.46)
  BOTTOM w0.216: DM1.107 84.45,29.82 v1(84.81,29.46) ; v1(97.76,74.52) 97.84,74.52 CPU1.AP35
M_A_A11: length 60.1
  TOP w0.216: v2(77.47,26.31) 77.34,26.31 77.12,26.09 v1(76.95,26.09)
  L4 w0.089: 91.1,64.81 91.1,65.17 94.2,68.27 94.2,70.97 v1(93.74,71.43)
  L4 w0.216: 91.1,64.81 91.1,54.21 76.18,39.28 76.18,36.57 73.82,34.21 73.82,31.89 74.92,30.78 74.92,28.75 76.35,27.32 76.35,26.63 76.89,26.09 v1(76.95,26.09)
  BOTTOM w0.216: v1(93.74,71.43) 93.84,71.43 CPU1.AW41 ; v1(76.95,26.09) 77.01,26.09 77.55,25.54 77.55,22.72 DM1.84
M_A_A12: length 59.6
  TOP w0.216: v2(75.66,28.54) 75.92,28.8 76.14,28.8 v1(76.17,28.82)
  L4 w0.089: 91.67,64.81 91.67,65.15 94.38,67.87 94.38,72.08 v1(93.75,72.71)
  L4 w0.216: 91.67,64.81 91.67,53.97 77.97,40.27 77.97,39.97 78.42,39.52 78.42,39.23 78.1,38.9 77.81,38.9 77.36,39.35 77.05,39.35 76.75,39.05 76.75,38.74 77.79,37.7 77.79,37.37 74.39,33.97 74.39,32.12 75.68,30.83 75.68,29.26 76.12,28.82 v1(76.17,28.82)
  BOTTOM w0.216: CPU1.AU41 94.19,73.04 93.87,72.71 v1(93.75,72.71) ; v1(76.17,28.82) 76.43,28.82 77.25,29.64 DM1.83
M_A_A13: length 59.8
  TOP w0.216: v1(88.41,29.46) v2(88.41,30.09)
  L4 w0.216: v1(97.76,73.87) 97.76,73.47 97.94,73.3 98.93,73.3 100.45,71.78 101.42,71.78 102.55,70.65 102.55,69.87 102.93,69.49 102.93,43.72 102.62,43.41 102.31,43.41 101.8,43.93 101.49,43.93 101.18,43.62 101.18,43.32 101.7,42.8 101.7,42.49 93.61,34.4 92.09,34.4 91.03,33.34 91.03,32.88 91.28,32.63 91.28,32.07 89.9,30.69 89.28,30.69 88.41,29.82 v1(88.41,29.46)
  BOTTOM w0.216: v1(97.76,73.87) 97.84,73.87 CPU1.AR35 ; v1(88.41,29.46) 88.05,29.82 DM1.119
