# Allegro board Janus Intel MB_13302-1.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
3V3_AON_S0 on TOP: 185.55,109.31 185.32,109.54 185.32,113.08 185,113.4 183.21,113.4 183.21,114.9 184.02,115.7 184.02,116.88 183.95,116.94 183.47,116.94 183.34,117.07 183.34,117.91 183.77,118.33 193.19,118.33 193.59,117.93 193.59,116.71 193.21,116.32 191.23,116.32 190.6,116.96 188.06,116.96 187.09,115.99 187.09,109.76 186.64,109.31
3V3_AON_S0 on TOP: 183.46,99.08 183.21,99.33 183.21,100.65 183.64,101.08 184.4,101.08 187.37,104.06 188.16,104.06 188.31,103.9 188.31,103.24 187.35,102.28 187.35,101.57 184.86,99.08
3V3_AON_S0 on TOP: 173.9,112.38 173.51,112.78 173.01,112.78 172.9,112.89 172.9,113.74 173.03,113.88 173.9,113.88 174.35,113.42 174.35,112.53 174.21,112.38
3V3_AON_S0 on TOP: 161.35,108.2 161.24,108.31 161.24,111.68 161.44,111.88 162.76,111.88 162.95,111.69 162.95,108.4 162.75,108.2 ; 5 cut-outs
3V3_AON_S0 on BOTTOM: 161.36,109.85 160.98,110.23 160.98,110.61 162,111.63 162.76,111.63 162.89,111.5 162.89,109.98 162.76,109.85
3V3_AON_S0 on BOTTOM: 175.9,97.96 175.28,98.58 175.28,99.37 174.99,99.66 174.57,99.66 174.04,99.13 157.73,99.13 157.3,99.56 157.3,100.02 157.37,100.09 167.33,100.09 168.15,100.91 173.68,100.91 173.68,100.91 175.01,100.91 175.13,100.79 175.13,100.32 175.23,100.21 175.7,100.21 175.93,99.98 175.93,99.47 175.94,99.47 175.94,98.83 176.22,98.55 177.64,98.55 177.92,98.84 177.92,99.13 177.1,99.95 176.74,99.95 176.74,100.85 176.82,100.93 177.44,100.93 177.67,101.16 177.67,102.48 177.37,102.79 177.37,103.4 177.49,103.52 178.13,103.52 178.41,103.24 178.41,100.55 178.58,100.38 180.22,100.38 180.74,99.86 180.74,98.59 180.6,98.45 179.35,98.45 178.86,97.96 ; 3 cut-outs
3V3_AON_S0 on BOTTOM: 173.31,111.88 173.09,112.1 173.09,113.82 173.21,113.93 173.79,113.93 174.25,113.47 174.25,112.31 173.82,111.88
3V3_AON_S0 on BOTTOM: 182.82,98.41 182.6,98.64 182.6,100.68 182.73,100.8 184.25,100.8 184.81,100.25 185.6,100.25 185.8,100.04 185.8,98.82 185.67,98.7 183.94,98.7 183.66,98.41 ; 3 cut-outs
3V3_AON_S0 on L3: 185.7,103.5 185.01,102.81 185.01,99.59 184.68,99.26 183.81,99.26 181.53,101.53 181.53,103.02 181.53,103.02 181.53,103.5 176.67,108.36 176.67,109.21 175.23,110.65 175.23,110.99 175,111.22 174.09,111.22 173.53,111.78 173.53,113.66 173.68,113.81 174.32,113.81 174.57,114.06 175.28,114.06 175.54,113.81 175.54,113.15 175.66,113.02 176.53,113.02 177.04,113.53 181.84,113.53 182.01,113.71 184.12,113.71 184.71,114.29 185.09,114.29 185.7,113.68
3V3_AON_S0 on L4: 153.15,96.28 151.82,97.6 151.82,101.02 152.85,102.05 152.85,102.22 153.92,103.29 156.28,103.29 161.17,108.18 161.17,110.94 160.96,111.15 160.12,111.15 159.38,111.89 158.12,111.89 153.97,116.04 151.26,116.04 151.06,116.25 151.06,117.33 152.55,118.82 160.33,118.82 163.24,115.91 163.24,105.56 158.82,101.14 158.82,98.75 156.35,96.28
5V_CRT_S0 on BOTTOM: 12.88,88.86 12.7,89.04 12.7,90.62 12.88,90.79 13.51,90.79 13.99,91.28 13.99,91.84 13.79,92.04 12.37,92.04 12.24,92.17 12.24,93.74 12.29,93.79 12.83,93.79 14.31,95.27 19,95.27 19.1,95.17 19.1,94.33 19,94.22 16.35,94.22 16.08,93.95 16.08,90.75 14.19,88.86 ; 2 cut-outs
5V_CRT_S0 on L3: 22.69,83.26 22.69,76.02 22.5,75.82 21.62,75.82 21.51,75.94 21.51,81.19 19.63,83.06 19.63,83.08 18.85,83.86 18.85,84.03 18.84,84.03 18.84,84.3 13.99,89.15 13.99,93.39 14.12,93.51 15.29,93.51 15.72,93.08 15.72,89.44 16.36,88.8 18.35,88.8 21.87,85.29 21.87,84.09
5V_CRT_S0_R on BOTTOM: 6.72,87.12 6.58,87.27 6.58,87.95 6.7,88.08 7.59,88.08 7.91,88.4 7.91,91.09 7.92,91.1 7.92,91.93 7.94,91.94 7.94,92.72 9.24,94.02 11.71,94.02 11.92,93.81 11.92,91.12 11.85,91.05 11.4,91.05 10.87,91.58 9.93,91.58 9.45,91.1 9.45,90.72 8.99,90.26 8.99,87.53 8.58,87.12 ; 1 cut-out
5V_PWR on BOTTOM: 138.15,10.2 138.12,10.23 129.87,10.23 129.74,10.36 129.74,21.35 130.17,21.79 137.34,21.79 137.49,21.63 137.49,12.39 138.99,10.89 138.99,10.28 138.91,10.2 ; 1 cut-out
5V_S0 on TOP: 190.75,25.31 190.65,25.42 190.65,28.75 190.34,29.05 190.34,40.09 186.54,43.89 186.54,59.39 187.67,60.52 187.67,64.41 187.69,64.42 187.69,69.42 192.94,74.67 196.82,74.67 196.87,74.62 196.87,74.53 196.16,73.82 196.16,69.51 191.03,64.38 191.03,58.7 190.52,58.19 190.52,46.19 195.11,41.61 195.11,32.36 195.15,32.33 195.15,32.3 195.63,31.82 195.96,31.82 195.96,31.82 196.42,31.82 196.7,31.54 196.7,28.11 195.4,28.11 192.61,25.31 ; 4 cut-outs
5V_S0 on TOP: 72.59,3.07 71.98,3.67 71.98,5.48 72.39,5.88 73.56,5.88 74.01,5.43 74.01,4.28 73.1,3.37 73.1,3.12 73.05,3.07 ; 1 cut-out
5V_S0 on TOP: 133.46,1.94 132.51,2.89 132.51,5.2 132.37,5.34 132.37,6.05 132.47,6.15 141.03,6.15 142.58,7.7 152.05,7.7 152.83,6.92 160.35,6.92 163.33,9.9 167.46,9.9 167.56,9.8 167.56,7.25 162.25,1.94 ; 3 cut-outs
5V_S0 on TOP: 45.79,1.67 45.39,2.07 45.39,6.2 45.44,6.24 46.47,6.24 47.86,4.85 47.86,2.09 47.44,1.67
5V_S0 on BOTTOM: 71.45,1.02 63.43,9.04 56.8,9.04 55.31,10.53 53.49,10.53 52.98,11.04 51.93,11.04 51.42,10.53 46.74,10.53 40.72,16.55 40.72,17.88 36.38,22.22 23.97,22.22 23.5,21.75 23.5,21.32 23.85,20.97 25.36,20.97 25.44,20.89 25.44,19.96 25.37,19.89 23.33,19.89 22.7,20.52 22.7,24.04 22.93,24.27 38.83,24.27 45.54,17.57 45.54,17.57 49.14,13.97 66.66,13.97 77.33,3.31 129.21,3.31 129.22,3.3 129.34,3.3 130.3,4.26 131.78,4.26 132.66,5.15 135.28,5.15 135.76,4.67 135.76,1.65 135.14,1.02
5V_S0 on BOTTOM: 191.87,72.31 191.77,72.41 191.77,74.67 192.25,75.15 193.38,75.15 193.62,75.4 193.62,76.9 193.75,77.03 194.54,77.03 194.64,76.93 194.64,75.31 194.64,75.31 194.64,73.33 193.62,72.31 ; 1 cut-out
5V_S0 on BOTTOM: 193.04,28.27 191.97,29.33 191.97,31.61 192.32,31.96 193.05,31.96 193.22,31.79 196.75,31.79 196.75,28.27
5V_S0 on BOTTOM: 45.38,1.92 45.23,2.07 45.23,3.35 45.43,3.54 47.51,3.54 47.86,3.19 47.86,2.1 47.69,1.92 ; 1 cut-out
5V_S0 on BOTTOM: 30.3,69.94 28.6,71.65 28.6,77.46 26.44,79.62 26.44,79.9 24.58,81.75 24.58,83.05 24.66,83.13 25.7,83.13 26.34,82.49 26.34,82.31 26.69,81.96 29.79,81.96 32.17,79.58 32.17,70.43 31.69,69.94
5V_S0 on BOTTOM: 20.07,94.35 19.99,94.43 19.99,96.1 20.09,96.21 21.68,96.21 21.8,96.08 21.8,94.9 21.26,94.35
5V_S0 on L3: 188.8,16.75 188.8,31.06 190.11,32.37 194.16,32.37 194.87,31.66 194.87,11.12 189.92,6.16 178.15,6.16 177.19,7.13 164.84,7.13 164.66,7.32 164.66,12.25 164.94,12.54 180.58,12.54 180.94,12.91 184.96,12.91 ; 2 cut-outs
5V_S0 on L3: 24.95,83.98 24.95,89.58 20.05,94.48 20.05,96.17 20.35,96.47 21.38,96.47 21.92,95.93 21.92,95.04 24.59,92.37 30.1,92.37 32.25,94.52 32.97,94.52 33.12,94.38 33.12,93.51 29.79,90.19 26.6,90.19 26.36,89.95 26.36,83.66 25.63,82.92 25.63,81.53 25.5,81.4 25.07,81.4 24.2,82.26 24.2,83.23
5V_S0 on L4: 33.9,62.14 34.12,61.91 34.12,61.25 36.04,59.34 36.04,50.52 32.94,47.43 32.94,46.19 31.45,44.69 31.45,44.69 31.3,44.54 31.3,44.52 30.92,44.13 30.92,43.35 25.72,38.16 25.72,22.32 25.6,22.2 23.85,22.2 22.1,23.95 22.1,33.34 23,34.24 23,39.86 26.08,42.94 27.2,42.94 28.05,43.78 28.05,44.9 31.34,48.2 31.34,49.27 32.51,50.43 32.51,53.04 33.28,53.81 33.28,55.88 32.46,56.71 32.46,58.55 31.51,59.49 31.51,66.81 30.55,67.77 30.55,69.41 29.66,70.3 29.66,70.68 30.3,71.32 33.09,71.32 33.9,70.51
5V_S0 on L4: 58.1,4.74 59.27,5.91 64.21,5.91 64.66,5.46 71.98,5.46 72.46,5.94 73.5,5.94 74.03,5.41 74.03,1.95 73.77,1.69 45.41,1.69 45.01,2.1 45.01,3.83 45.92,4.74
5V_S5 on TOP: 32.99,28.69 32.52,29.17 30.59,29.17 30.37,29.39 30.37,30.13 30.56,30.32 32.38,30.32 32.62,30.55 32.62,31.54 32.95,31.88 33.95,31.88 34.41,32.34 34.41,33.5 34.54,33.64 36.74,33.64 37.46,34.36 37.46,34.93 37.54,35 38.92,35 39.01,34.92 39.01,32.3 39.25,32.06 41.27,32.06 41.38,31.96 41.38,31.07 40.54,30.23 38.67,30.23 37.14,28.69 ; 5 cut-outs
5V_S5 on TOP: 132.48,7.56 132.4,7.64 132.4,10.9 132.56,11.07 139.01,11.07 139.19,10.89 139.19,7.71 139.04,7.56 ; 3 cut-outs
5V_S5 on BOTTOM: 77.38,3.42 66.63,14.17 49.49,14.17 36.94,26.72 36.77,26.89 35.32,26.89 34.68,27.53 34.68,31.17 35.46,31.94 39.85,31.94 42.17,29.62 42.17,28.17 42.33,28.01 43.02,28.01 50,21.04 57.2,21.04 59,19.24 60.02,19.24 60.08,19.29 60.08,19.35 61.69,19.35 61.93,19.59 68.52,19.59 79.24,8.87 119.55,8.87 120.09,8.32 126.06,8.32 127.71,9.97 148.68,9.97 150.88,7.77 154.18,7.77 154.28,7.67 154.28,6.65 154.23,6.6 152.6,6.6 152.52,6.52 152.52,4.97 152.24,4.68 149,4.68 148.63,5.04 148.63,6.39 148.49,6.54 147.01,6.54 146.8,6.33 146.8,5.92 146.71,5.83 139.41,5.83 138.96,5.38 131.22,5.38 129.26,3.42 ; 5 cut-outs
5V_S5 on L3: 153.61,14.7 155.91,14.7 156.41,14.2 156.41,11.64 155.34,10.57 155.34,9.31 152.3,6.27 151,6.27 150.75,6.52 150.75,9.95 153.39,12.6 153.39,14.48
+3V_1D5V_AVDD on TOP: 31.13,4.06 31.07,4.12 31.07,4.48 31.51,4.92 32.44,4.92 33.6,6.09 33.9,6.09 33.92,6.07 33.92,4.16 33.82,4.06 ; 2 cut-outs
+3V_AVDD on TOP: 38.25,7.41 38.18,7.48 38.18,8.63 38.19,8.65 39.13,8.65 39.15,8.63 39.15,8.44 38.79,8.09 38.79,7.45 38.75,7.41
+3V_AVDD on TOP: 31.82,7.55 31.67,7.7 31.67,8.17 32.13,8.64 33.08,8.64 33.09,8.63 33.09,8.45 33.07,8.43 33.05,8.43 32.16,7.55
+5V_PVDD on TOP: 39.58,1.39 39.41,1.55 39.41,3.11 39.2,3.32 38.4,3.32 38,2.92 35.68,2.92 35.47,3.13 34.45,3.13 34.32,3.26 34.32,6.22 34.45,6.35 34.45,6.36 34.83,6.74 34.93,6.74 35.02,6.65 35.02,6.59 34.89,6.47 34.89,5.93 35.54,5.29 35.54,4.87 35.68,4.72 37.44,4.72 37.71,5 37.71,6.12 36.93,6.9 36.93,8.17 36.95,8.19 37.11,8.19 37.13,8.16 37.13,7.44 37.13,7.43 37.13,7.18 37.25,7.06 37.36,7.06 38.93,5.49 39.3,5.49 40.09,4.71 40.63,4.71 41.83,3.51 42.31,3.51 43.03,4.22 43.03,6.14 43.17,6.29 45.07,6.29 45.25,6.11 45.25,2.37 45,2.13 45,2.13 44.26,1.39 ; 8 cut-outs
+V1.05DX_MODPHY_PCH on TOP: 112.82,86.31 112.56,86.58 112.56,88.03 113.32,88.79 113.32,91.08 113.46,91.21 113.46,92.02 113.32,92.15 113.32,92.87 118.16,97.7 118.5,97.7 118.69,97.89 118.69,98.81 118.78,98.9 120.38,98.9 120.49,98.78 120.49,96.14 119.5,95.14 118.7,95.14 117.96,94.39 117.96,93.36 116.81,92.22 116.81,91.91 117.27,91.45 117.27,90.93 117.08,90.74 117.08,86.47 116.93,86.31 ; 3 cut-outs
+V1.05DX_MODPHY_PCH on BOTTOM: 112.81,86.52 112.61,86.72 112.61,87.11 113.74,88.24 114.48,88.24 114.6,88.12 114.6,87.81 114.42,87.64 114.2,87.64 114.07,87.51 114.07,86.76 113.96,86.64 113.27,86.64 113.14,86.52
+V1.05DX_MODPHY_PCH on L3: 112.58,86.54 114.57,86.54 114.7,86.67 114.7,88.11 114.52,88.29 113.07,88.29 112.8,88.57 112.8,92.17 116.29,95.67 118.3,95.67 118.58,95.95 118.58,96.96 118.43,97.11 115.82,97.11 111.36,92.65 111.36,88.4 112.49,87.27 112.49,86.63
+V1.05S_CORE_PCH on TOP: 110.71,85.54 110.62,85.63 110.62,86.42 110.05,86.98 110.05,90.72 109.61,91.15 109.61,93.13 111.45,94.96 111.45,95.06 111.91,95.52 111.91,96.92 112.13,97.14 113.46,97.14 113.7,97.39 115.48,97.39 115.9,97.81 115.9,98.01 116.55,98.66 116.55,98.76 116.7,98.91 118.35,98.91 118.44,98.82 118.44,98.05 118.24,97.86 118.06,97.86 113.19,92.99 113.19,88.68 113.07,88.56 112.89,88.56 112.42,88.09 112.42,86.29 112.41,86.28 112.41,85.7 112.25,85.54 ; 2 cut-outs
+V1.05S_CORE_PCH on L4: 106.48,79.82 106.82,79.48 113.38,79.48 113.68,79.78 114.44,79.78 114.86,80.19 114.86,80.45 114.17,81.13 114.17,81.23 113.63,81.77 113.63,88.49 113.03,89.1 111.96,89.1 111.33,89.73 110.75,89.73 109.55,88.53 109.55,82.05 109.42,81.92 107.62,81.92 107.59,81.95 106.66,81.95 106.48,81.77
AVCC33 on BOTTOM: 19.06,74.3 19,74.36 19,74.95 19.68,75.63 19.68,75.86 18.41,77.13 18.41,77.62 18.49,77.7 18.53,77.7 18.53,77.69 19.35,77.69 19.68,78.02 20.24,78.02 20.29,77.97 20.29,77.44 20.55,77.18 20.93,77.18 21.08,77.03 21.08,74.76 20.62,74.3 ; 2 cut-outs
GND on TOP: 107.6,102.65 107.55,102.7 107.55,106.48 107.77,106.7 110.21,106.7 110.34,106.57 110.34,105.61 109.75,105.02 109.35,105.02 108.9,104.57 108.9,103.35 108.21,102.65
GND on TOP: 118.19,123.18 118.04,123.33 118.04,123.82 118.23,124.01 118.23,125.22 118.34,125.34 118.75,125.34 118.91,125.18 118.91,123.56 118.52,123.18
GND on TOP: 173.68,98.85 173.45,99.08 173.45,99.99 173.61,100.14 175.13,100.14 175.54,99.73 176.51,99.73 176.58,99.66 176.58,98.91 176.53,98.85 ; 1 cut-out
GND on TOP: 157.55,82.62 156.28,83.89 156.28,88.33 156.41,88.46 160.35,88.46 161.74,87.06 162.76,87.06 162.89,86.94 162.89,83.89 162.76,83.76 161.36,83.76 161.11,83.51 160.63,83.51 159.74,82.62
GND on TOP: 180.63,25.06 180.51,25.18 180.51,25.91 180.58,25.98 183.11,25.98 183.27,25.82 183.27,25.13 183.2,25.06 ; 1 cut-out
GND on TOP: 126.26,2 126.13,2.12 126.13,3.55 126.18,3.6 129.61,3.6 129.61,3.61 129.66,3.55 129.66,2.96 129.77,2.86 131.57,2.86 131.7,2.99 131.7,3.47 131.8,3.57 132.27,3.57 132.35,3.5 132.35,2.23 132.24,2.12 132.23,2.12 132.11,2 ; 3 cut-outs
GND on TOP: 83.21,1.49 83.13,1.57 83.13,3.32 83.18,3.37 89.91,3.37 89.99,3.29 89.99,1.57 89.91,1.49
GND on TOP: 116.85,63.24 116.17,63.92 116.17,64.63 116.27,64.73 117.58,64.73 117.78,64.53 117.78,63.37 117.65,63.24
GND on TOP: 174.02,113.93 173.84,114.11 173.84,115.14 173.98,115.28 175.87,115.28 175.98,115.18 175.98,114.65 175.81,114.49 175.5,114.49 175.28,114.26 174.74,114.26 174.41,113.93
GND on TOP: 51.07,23.29 50.51,23.85 50.51,25.91 50.8,26.2 50.8,26.23 51.25,26.69 51.25,30.49 53.19,32.43 60.53,32.43 62.38,34.28 62.38,36.84 62.68,37.15 66.37,37.15 66.78,36.74 66.78,29.8 66.37,29.39 66.37,23.57 66.09,23.29 54.73,23.29 54.51,23.52 54.51,25.49 54.35,25.65 53.95,25.65 53.62,25.32 53.21,25.32 53.03,25.49 52.73,25.49 52.27,25.04 52.27,23.39 52.17,23.29 ; 2 cut-outs
GND on TOP: 190.47,74.77 189.79,75.46 189.79,79.54 193.32,83.08 193.32,84.27 193.72,84.68 197.41,84.68 197.48,84.61 197.48,80.35 196.58,79.45 196.58,76.26 196.31,75.99 196.31,75.02 196.06,74.77
GND on TOP: 67,79.51 65.43,81.08 65.43,84.62 65.58,84.78 65.58,87.34 65.33,87.6 64.72,87.6 64.54,87.42 64.54,80.76 64.34,80.56 62.86,80.56 60.27,83.15 60.27,92.8 66.27,98.8 69.16,98.8 69.42,98.54 69.42,82.69 69.8,82.31 69.8,81.29 70.26,80.83 70.26,79.93 69.83,79.51 ; 2 cut-outs
GND on TOP: 101.47,112.64 101.29,112.82 101.29,115.26 101.55,115.51 103.07,115.51 103.32,115.77 103.32,118.13 104.01,118.81 110.82,118.81 111.33,118.31 112.47,118.31 112.98,117.8 112.98,114.47 111.15,112.64
GND on TOP: 174.41,132.57 173.96,133.02 171.17,133.02 171.06,133.13 171.06,134.16 171.15,134.25 174.03,134.25 175.06,133.22 175.06,132.8 174.82,132.57 ; 2 cut-outs
GND on TOP: 184.01,118.52 182.95,119.58 182.95,120.54 183.04,120.63 187.33,120.63 187.55,120.41 187.55,118.74 187.33,118.52 ; 2 cut-outs
GND on TOP: 170.47,123.81 170.41,123.86 170.41,124.55 170.31,124.65 169.82,124.65 169.76,124.72 169.76,125.12 169.86,125.22 170.82,125.22 170.97,125.07 170.97,123.87 170.91,123.81
GND on TOP: 105.2,56.48 104.38,57.3 104.38,67.04 103.91,67.51 103.91,77.33 103.25,78 103.25,78.76 103.81,79.32 105,79.32 105.18,79.14 105.18,78.71 105.46,78.43 106.68,78.43 106.91,78.2 106.91,77.33 106.55,76.98 106.55,75.76 106.45,75.66 105.81,75.66 105.74,75.58 105.74,74.9 106.02,74.62 107.41,74.62 107.52,74.72 107.77,74.72 107.87,74.62 107.87,74.36 106.42,72.91 106.42,62.99 108.4,61 108.4,58.59 110.16,56.84 110.16,56.56 110.08,56.48 ; 3 cut-outs
GND on TOP: 94.56,15.69 94.18,16.07 94.18,18.48 100.53,18.48 100.78,18.23 100.78,16.32 100.59,16.13 99.77,16.13 99.33,15.69 ; 2 cut-outs
GND on TOP: 111.2,138.5 111.07,138.63 111.07,140.91 111.58,141.42 115.9,141.42 116.28,141.04 116.28,138.88 115.9,138.5 ; 2 cut-outs
GND on TOP: 182.71,39.13 182.71,39.13 181.74,39.13 181.69,39.19 181.69,40.99 183.39,42.69 183.39,43.95 183.07,44.27 183.07,45.85 184.69,47.47 186.18,47.47 186.37,47.27 186.37,42.68 185.55,41.86 185.55,40.8 186.96,39.39 186.96,39.32 186.77,39.13 ; 2 cut-outs
GND on TOP: outline of 149 points within 106.42,127.37 203.19,157.39 ; 41 cut-outs
GND on TOP: 152.59,78.86 152.35,79.1 152.35,80.52 152.68,80.85 154.23,80.85 154.54,80.53 154.54,79.28 154.12,78.86 ; 1 cut-out
GND on TOP: 37.45,18.14 37.28,18.32 37.28,19.22 37.36,19.3 37.36,20.52 36.8,21.08 31.93,21.08 31.93,21.08 31.49,21.08 31.29,21.28 31.29,22.27 31.98,22.96 37.03,22.96 38.57,21.42 38.57,18.77 37.94,18.14 ; 5 cut-outs
GND on TOP: 187.81,28.92 186.49,30.24 186.49,31.44 186.68,31.63 189.87,31.63 190.05,31.46 190.05,29.14 189.82,28.92 ; 1 cut-out
GND on TOP: 156.41,71.57 156.16,71.82 156.16,73.86 156.73,74.43 156.73,75.95 157.55,76.78 162.76,76.78 162.89,76.65 162.89,73.6 162.76,73.47 161.62,73.47 161.11,72.97 161.11,71.95 160.73,71.57
GND on TOP: 125.42,28.26 125.3,28.39 125.3,30.29 125.17,30.42 123.9,30.42 123.77,30.55 123.77,33.22 123.9,33.34 125.42,33.34 125.93,32.83 128.34,32.83 129.36,31.82 129.36,29.28 129.23,29.15 128.47,29.15 127.58,28.26 ; 2 cut-outs
GND on TOP: 194.05,104.34 193.8,104.59 193.8,109.46 193.82,109.47 193.82,110.75 194.46,111.4 195.83,111.4 196.16,111.07 196.16,104.59 195.91,104.34
GND on TOP: 113.43,64.51 113.17,64.76 113.17,65.36 113.87,66.06 114.48,66.06 114.58,65.96 114.58,64.62 114.46,64.51 ; 1 cut-out
GND on TOP: 91.21,21.44 91,21.65 91,24.18 90.67,24.51 90.67,26.8 90.49,26.98 90.49,29.83 90.76,30.1 90.76,35.29 91.11,35.64 111.12,35.64 111.53,35.23 111.53,23.97 111.52,23.96 111.52,22.4 111.23,22.1 110.48,22.1 110.09,21.71 102.83,21.71 102.56,21.44 ; 10 cut-outs
GND on TOP: 49.53,74.36 49.49,74.4 49.49,79.1 49.73,79.34 49.73,80.69 49.88,80.84 50.62,80.84 51.13,80.33 51.13,76.5 50.95,76.32 50.59,76.32 50.17,75.9 50.17,74.36 ; 3 cut-outs
GND on TOP: 133.68,28.26 133.55,28.39 133.55,29.53 133.04,30.04 131.77,30.04 131.39,29.66 131.39,29.28 131.26,29.15 130.63,29.15 130.38,29.41 130.38,30.68 132.92,33.22 135.96,33.22 136.09,33.09 136.09,30.17 136.22,30.04 136.22,28.52 135.96,28.26 ; 2 cut-outs
GND on TOP: 131.09,56.89 129.84,58.13 129.26,58.13 126.62,60.77 126.62,61.64 127.15,62.17 127.15,62.53 127.56,62.93 127.56,63.37 127.25,63.67 126.03,63.67 124.94,62.58 124.94,62.2 124.81,62.07 124.48,62.07 124.36,62.2 124.36,62.76 124.71,63.11 124.71,63.59 124.51,63.8 122.68,63.8 122.68,66.31 122.86,66.49 124.56,66.49 124.74,66.31 127.83,66.31 127.99,66.15 131.17,66.15 131.78,65.55 134.57,65.55 134.74,65.37 134.74,57.27 134.36,56.89 ; 1 cut-out
GND on TOP: 83.75,114.82 83.49,115.08 83.49,120.02 83.72,120.25 85.32,120.25 85.39,120.18 85.39,114.88 85.33,114.82
GND on TOP: 159.89,117.21 159.34,117.76 157.83,117.76 157.75,117.84 157.75,119.09 157.11,119.74 157.11,120.67 157.23,120.79 157.28,120.79 157.29,120.79 159.66,120.79 159.79,120.66 159.79,119.78 160.26,119.3 160.26,118.07 160.57,117.76 160.9,117.76 161.03,117.63 161.03,117.26 160.98,117.21 ; 7 cut-outs
GND on TOP: 13.74,30.8 13.61,30.93 13.61,31.92 13,32.53 3.1,32.53 3.02,32.61 3.02,33.93 2.41,34.54 0.63,34.54 0.53,34.64 0.53,35.32 0.99,35.78 3.22,35.78 3.93,35.07 8.56,35.07 9.04,34.59 9.9,34.59 10.51,35.2 10.51,37.05 10.59,37.13 14.4,37.13 14.98,37.71 14.98,38.57 14.37,39.18 10.67,39.18 10.49,39.36 10.49,41.55 10.5,41.56 10.5,46.84 10.64,46.98 11.17,46.98 11.33,46.83 11.33,41.9 12.39,40.84 15.15,40.84 16.05,39.93 16.05,38.83 16.38,38.5 21.18,38.5 23.27,36.41 23.27,31.16 23.05,30.94 19.08,30.94 19.07,30.95 14.7,30.95 14.55,30.8 ; 1 cut-out
GND on TOP: outline of 152 points within 3.05,12.26 62.53,74.57 ; 16 cut-outs
GND on TOP: 158.54,96 157.92,96.63 157.92,100.12 157.5,100.53 157.5,103.91 157.92,104.33 157.92,105.03 158.13,105.24 160.72,105.24 160.84,105.12 160.84,104.78 160.54,104.48 160.54,96.38 160.16,96 ; 8 cut-outs
GND on TOP: 182.95,78.13 182.68,78.4 182.68,80.85 182.7,80.87 184.85,80.87 184.94,80.78 184.94,78.42 184.65,78.13
GND on TOP: 8.89,77.97 7.39,79.47 7.39,80.79 7.52,80.92 7.95,80.92 8.79,80.08 9.6,80.08 10.21,79.47 11.22,79.47 11.43,79.68 11.43,80.13 11.56,80.26 12.9,80.26 13.31,79.85 14.75,79.85 14.77,79.83 14.77,79.06 14.74,79.04 13.15,79.04 12.93,78.81 11.76,78.81 11.3,79.27 10.21,79.27 9.93,78.99 9.93,78.07 9.83,77.97 ; 3 cut-outs
GND on TOP: 133.25,105.66 133.05,105.86 133.05,108.03 133.25,108.23 133.25,109.65 133.96,110.35 134.72,110.35 135.25,109.82 135.25,105.87 135.03,105.66 ; 2 cut-outs
GND on TOP: 110.44,12.39 110.31,12.51 110.31,16.83 110.44,16.96 112.09,16.96 112.34,16.71 112.34,12.64 112.09,12.39 ; 5 cut-outs
GND on TOP: 16.71,25.47 16.46,25.72 16.46,26.84 16.61,26.99 20.11,26.99 20.37,27.25 23.7,27.25 23.8,27.14 23.8,26.48 23.59,26.28 21.69,26.28 21.08,25.67 17.45,25.67 17.24,25.47 ; 4 cut-outs
GND on TOP: outline of 109 points within 3.27,63.44 29.06,81.21 ; 7 cut-outs
GND on TOP: 44.89,39.19 44.78,39.31 44.78,46.35 64.99,66.56 64.99,74.65 66.84,76.5 73.13,76.5 74.56,75.08 74.56,70.07 65.37,60.88 65.37,56.09 55.4,46.12 55.4,41.87 52.73,39.19
GND on TOP: 95.78,101.64 95.63,101.8 95.63,102.3 95.27,102.66 94.33,102.66 94.08,102.91 94.08,104.87 96.54,107.33 104.54,107.33 104.73,107.15 104.73,102.41 104.37,102.05 101.52,102.05 101.27,102.3 99.11,102.3 98.45,101.64
GND on TOP: 15.03,47.77 14.98,47.82 14.98,48.51 14.42,49.06 10.59,49.06 10.49,49.17 10.49,50.59 9.74,51.59 8.58,51.12 3.93,51.12 3.31,50.49 3.31,50.85 2.99,50.54 0.86,50.54 0.68,50.72 0.68,51.68 0.79,51.78 1.6,51.78 2.23,52.42 2.23,53.46 2.41,53.64 3.31,53.64 3.31,53.76 10.84,53.76 16.15,48.46 16.15,47.9 16.03,47.77
GND on TOP: 172.36,107.31 172.31,107.36 172.31,108.69 172.36,108.75 172.4,108.75 172.4,108.74 172.75,108.74 172.85,108.84 172.85,109.44 173,109.59 173.5,109.59 173.66,109.44 173.66,108.8 173.83,108.63 173.83,108.16 173.54,107.87 173.54,107.46 173.39,107.31 ; 2 cut-outs
GND on TOP: outline of 176 points within 3.98,81.14 100.78,157.39 ; 13 cut-outs
GND on TOP: 127.71,117.92 127.58,118.05 127.58,119.19 127.45,119.32 127.45,122.5 127.71,122.75 130.25,122.75 130.38,122.62 130.38,121.1 130.12,120.85 130.12,119.83 130.25,119.7 130.25,118.05 130.12,117.92 ; 2 cut-outs
GND on TOP: 147.6,100.42 147.36,100.66 147.36,108.46 147.6,108.7 150.64,108.7 150.85,108.49 150.85,106.42 151.07,106.2 151.32,106.2 151.68,106.56 151.68,106.97 151.71,107 152.65,107 152.75,106.91 152.75,106.09 152.49,105.83 151.99,105.83 151.53,105.38 151.53,102.92 151.28,102.66 149.31,102.66 148.6,101.95 148.6,100.61 148.41,100.42
GND on TOP: 44.34,72.63 44.24,72.73 44.24,73.67 44.63,74.06 46.22,74.06 46.27,74.02 46.27,72.87 46.03,72.63
GND on TOP: 134.21,148.23 134.03,148.4 134.03,150.03 134.19,150.18 135.51,150.18 135.81,149.88 135.81,148.3 135.76,148.25 135.76,148.23
GND on TOP: 41.44,13.14 41.4,13.18 41.4,13.59 41.59,13.79 41.59,14.4 41.75,14.56 42.03,14.56 42.17,14.42 42.17,13.34 41.97,13.14
GND on TOP: 104.47,139.54 104.45,139.55 104.45,140.64 104.73,140.92 105.49,140.92 105.62,140.79 105.62,140.44 105.23,140.04 105.23,139.59 105.17,139.54
GND on TOP: 79.47,9.24 78.97,9.75 78.97,14.09 79.22,14.34 83.95,14.34 84.4,13.89 84.4,9.47 84.17,9.24 ; 5 cut-outs
GND on TOP: 23.9,6.32 23.83,6.39 23.83,10.67 23.95,10.79 25.04,10.79 25.27,10.56 25.27,6.62 24.97,6.32
GND on TOP: 116.16,72.57 115.01,73.72 115.01,75.43 115.15,75.57 115.89,75.57 116.04,75.42 116.04,75.17 116.3,74.91 116.56,74.91 116.76,74.71 116.76,74.48 116.61,74.33 116.3,74.33 116.1,74.12 116.1,73.64 116.25,73.49 117.27,73.49 117.61,73.83 117.61,74.3 117.71,74.4 118.08,74.4 118.2,74.28 118.2,73.79 118.06,73.65 118.06,72.8 117.83,72.57
GND on TOP: 105.64,82.91 105.09,83.47 105.09,84.23 104.79,84.54 104.15,84.54 104.06,84.62 104.06,85.26 104.19,85.39 105.14,85.39 105.91,84.61 107.88,84.61 108.02,84.75 108.5,84.75 108.58,84.67 108.58,83.72 108.44,83.58 108.31,83.58 107.84,83.11 106.47,83.11 106.4,83.11 106.2,82.91 ; 2 cut-outs
GND on TOP: 13.36,80.56 13.03,80.89 13.03,81.09 12.77,81.35 11.76,81.35 11.15,81.96 10.25,81.96 9.92,81.63 9.92,81.24 9.85,81.17 9.29,81.17 7.9,82.57 7.9,83.65 8.02,83.78 8.59,83.78 8.66,83.71 9.34,83.71 9.5,83.86 9.85,83.86 9.95,83.76 9.95,83.08 10.41,82.62 12.75,82.62 13.28,82.08 13.28,81.42 13.61,81.09 13.61,80.92 13.66,80.87 14.73,80.87 14.76,80.84 14.76,80.61 14.7,80.56 ; 2 cut-outs
GND on TOP: 182.69,106.9 182.49,107.1 181.98,107.1 181.71,107.37 181.71,108.78 182.14,109.21 186.28,109.21 186.41,109.08 186.41,107.71 186.18,107.47 185.46,107.47 184.89,106.9
GND on TOP: 111.65,97.26 110.88,98.02 110.88,98.4 111.18,98.69 113.13,98.69 113.61,99.17 115.44,99.17 115.67,98.95 115.67,97.86 115.34,97.53 113.6,97.53 113.33,97.26 ; 3 cut-outs
GND on TOP: 168.09,118.61 167.71,118.99 167.71,120.77 167.97,121.02 169.21,121.02 169.36,121.18 169.36,121.81 169.42,121.86 169.95,121.86 170.08,121.73 170.08,121.1 169.87,120.9 169.87,120.01 170.76,119.12 170.76,118.74 170.63,118.61 170.25,118.61 169.62,119.25 169.11,119.25 168.47,118.61
GND on TOP: 39.76,58.66 39.37,59.04 39.37,60.44 38.74,61.08 38.74,63.12 38.65,63.21 38.65,63.45 38.11,63.99 38.11,64.5 38.23,64.62 39.23,64.62 39.33,64.52 39.33,63.55 40.03,62.85 42.04,62.85 42.3,62.6 42.3,59.04 41.91,58.66 ; 11 cut-outs
GND on TOP: 74.33,60.66 74.11,60.88 74.11,66.29 74.79,66.97 76.3,66.97 76.4,66.87 76.4,60.76 76.3,60.66
GND on TOP: outline of 242 points within 27.73,0.51 203.34,113.81 ; 17 cut-outs
GND on TOP: 87.2,82.11 86.81,82.49 86.81,86.56 87.2,86.94 102.05,86.94 102.31,86.68 102.31,84.52 99.9,82.11
GND on TOP: 150.53,119.54 150.48,119.6 150.48,122.8 150.47,122.8 150.47,122.94 149.75,123.66 148.6,123.66 147.65,122.71 147.65,121.18 147.55,121.08 147.17,121.08 147.07,121.18 147.07,123.05 147.47,123.45 147.47,123.89 149.24,125.66 149.24,130.85 149.76,131.37 163.74,131.37 164.36,130.74 164.36,126.07 163.51,125.22 163.51,123.36 163.03,122.88 163.03,121.48 162.84,121.29 162.84,120.79 162.7,120.65 161.94,120.65 161.73,120.43 161.49,120.43 161.33,120.59 161.33,120.86 161.96,121.49 161.96,124.39 163.02,125.45 163.02,129.54 162.67,129.89 155.55,129.89 154.37,128.72 154.37,128.22 154.37,128.21 154.37,125.27 154.19,125.09 151.34,125.09 151.2,124.95 151.2,122.37 151.4,122.17 151.4,119.56 151.38,119.54 ; 18 cut-outs
GND on TOP: 143.41,140.49 142.94,140.96 142.93,140.96 142.69,141.21 142.69,144.1 143.79,145.2 144.48,145.2 144.55,145.13 144.55,140.58 144.46,140.49 ; 3 cut-outs
GND on TOP: 177.32,126.22 177.17,126.38 177.17,126.77 177.29,126.89 178.84,126.89 179.2,127.25 181.31,127.25 181.42,127.14 181.42,126.43 181.21,126.22 ; 1 cut-out
GND on TOP: 113.99,100.91 113.87,101.03 113.87,104.34 113.99,104.46 115.52,104.46 115.9,104.08 115.9,102.18 115.77,102.05 115.77,101.16 115.52,100.91 ; 1 cut-out
GND on TOP: 148.26,115.49 148.09,115.66 148.09,118.5 148.23,118.65 149.95,118.65 150.06,118.54 150.06,115.68 149.86,115.49 ; 3 cut-outs
GND on TOP: outline of 89 points within 163.14,109.51 172.79,119.12 ; 28 cut-outs
GND on BOTTOM: 134.06,28.39 133.04,29.41 133.04,32.96 133.3,33.22 136.09,33.22 136.22,33.09 136.22,30.93 136.47,30.68 136.47,28.77 136.09,28.39
GND on BOTTOM: 122.16,57.41 121.5,58.07 121.5,59.26 121.66,59.43 122.56,59.43 123.42,58.57 123.42,57.8 123.03,57.41
GND on BOTTOM: 130.91,89.45 130.81,89.55 130.81,89.98 131.04,90.21 131.04,91.66 131.19,91.81 131.67,91.81 132.05,92.19 134.16,92.19 134.21,92.14 134.21,91.79 134.06,91.64 132.92,91.64 132.33,91.05 132.33,90.29 132.15,90.11 132.15,89.6 132,89.45 ; 2 cut-outs
GND on BOTTOM: 182.06,108.15 181.94,108.27 181.94,108.53 182.57,109.16 183.33,109.16 183.46,109.03 183.46,108.78 183.59,108.65 185.37,108.65 185.62,108.91 185.62,110.05 185.75,110.18 186.64,110.18 187.02,110.56 187.02,112.72 186.76,112.97 185.37,112.97 185.11,112.72 185.11,111.45 184.99,111.32 184.22,111.32 184.1,111.45 184.1,112.59 183.72,112.97 182.45,112.97 182.32,113.1 182.32,113.35 182.45,113.48 186.89,113.48 187.65,112.72 187.65,109.16 186.64,108.15 ; 1 cut-out
GND on BOTTOM: 156.41,71.57 156.16,71.82 156.16,73.86 156.74,74.44 156.74,75.96 157.17,76.4 157.68,76.4 157.93,76.65 157.93,77.03 160.04,79.14 163.42,79.14 163.52,79.04 163.52,78.55 163.4,78.43 161.87,78.43 161.24,77.79 161.24,75.63 161.36,75.51 162.76,75.51 162.89,75.38 162.89,72.33 162.76,72.2 161.36,72.2 160.73,71.57 ; 2 cut-outs
GND on BOTTOM: 121.91,53.58 121.97,53.64 125.77,53.64 126.66,54.52 131.78,54.52 132.47,53.84 132.47,50.4 132.16,50.09 131.76,50.09 131.75,50.08 129.95,50.08 129.61,49.73 129.61,49.02 129.35,48.75 122.31,48.75 121.91,49.16
GND on BOTTOM: outline of 88 points within 0.51,63.34 28.24,85.92 ; 12 cut-outs
GND on BOTTOM: 192.86,103.73 192.68,103.91 192.68,105.61 192.78,105.71 194.4,105.71 194.65,105.46 194.65,103.86 194.52,103.73 ; 2 cut-outs
GND on BOTTOM: 115.94,12.24 115.68,12.5 115.68,15.65 115.85,15.82 119.33,15.82 119.58,15.56 119.58,12.52 119.3,12.24
GND on BOTTOM: 95.7,15.82 95.45,16.07 95.45,17.61 95.31,17.75 94.81,17.75 94.7,17.87 94.7,18.51 94.85,18.66 100.86,18.66 101.04,18.48 101.04,15.94 100.91,15.82 ; 1 cut-out
GND on BOTTOM: 95.88,101.67 95.58,101.97 95.58,102.3 95.32,102.56 93.47,102.56 93.35,102.68 93.16,102.68 93.04,102.81 93.04,102.81 93.04,102.99 92.97,103.07 92.97,112.95 93.17,113.15 99.83,113.15 100.03,112.95 100.03,103.58 98.12,101.67 ; 1 cut-out
GND on BOTTOM: 135.2,94.18 135.2,95.19 134.95,95.45 133.8,95.45 133.55,95.19 133.17,95.19 133.04,95.06 132.79,95.06 132.66,95.19 132.66,95.45 132.79,95.57 133.3,95.57 133.55,95.83 135.96,95.83 136.22,95.57 136.22,94.3 136.09,94.18
GND on BOTTOM: 190.32,72.23 189.99,72.56 189.99,75.28 190.24,75.53 191.79,75.53 192.15,75.89 192.58,75.89 192.68,75.79 192.68,75.4 192.56,75.28 192.17,75.28 191.46,74.57 191.46,72.36 191.34,72.23 ; 1 cut-out
GND on BOTTOM: 151.09,9.78 151.04,9.84 151.04,13.6 151.25,13.81 153.13,13.81 153.42,13.52 153.42,9.95 153.26,9.78
GND on BOTTOM: 113.74,99.28 113.28,99.74 113.28,100.12 113.57,100.41 113.57,103.69 113.84,103.96 115.48,103.96 115.88,103.56 115.88,101.15 114.89,100.16 114.89,99.42 114.75,99.28 ; 1 cut-out
GND on BOTTOM: 112.56,34.32 112.13,34.74 112.13,40.99 112.57,41.43 116.8,41.43 117.06,41.17 117.06,34.94 116.43,34.32
GND on BOTTOM: 152.83,4.8 152.67,4.96 152.67,6.27 152.8,6.41 154.17,6.41 154.6,6.84 154.6,8 154.82,8.22 155.32,8.22 155.6,8.5 155.6,8.86 155.69,8.95 156.36,8.95 156.46,8.85 156.46,6.38 154.89,4.8
GND on BOTTOM: 134.52,103.01 134.52,104.87 134.68,105.03 138.46,105.03 138.86,104.63 138.86,103.06 138.58,102.79 134.75,102.79
GND on BOTTOM: 127.58,97.99 127.2,98.37 127.2,99.13 127.33,99.26 127.84,99.26 128.34,99.76 128.34,100.91 128.47,101.03 128.98,101.03 129.11,100.91 129.11,99.69 128.14,98.72 128.14,98.16 127.96,97.99 ; 1 cut-out
GND on BOTTOM: 150.58,122.68 150.45,122.81 150.45,125.27 150.51,125.33 152.51,125.33 152.64,125.19 152.64,122.93 152.4,122.68 ; 2 cut-outs
GND on BOTTOM: 15.96,28.97 14.97,29.95 12.91,29.95 12.91,30.63 13.37,31.76 12.4,32.51 2.82,32.51 2.82,33.5 2.52,34.21 1.81,34.51 0.51,34.51 0.51,35.52 0.78,35.79 3.18,35.79 3.25,35.65 3.62,35.24 4.15,35.09 8.4,35.09 9.53,34.63 10.28,35.6 10.28,37.14 13.77,37.14 14.77,38.15 13.77,39.15 10.28,39.15 10.28,47.05 11.42,47.05 11.42,41.79 11.88,41.33 14.98,41.33 17.18,39.14 20.55,39.14 20.95,38.73 22.5,37.18 23.68,36.01 23.68,29.24 23.4,28.97 ; 2 cut-outs
GND on BOTTOM: 179.19,52.68 179.02,52.85 179.02,53.43 178.66,53.79 178.66,54.65 177.85,55.47 177.85,56.35 177.95,56.46 181.61,56.46 182.38,55.7 184.09,55.7 184.33,55.46 184.33,54.33 184.12,54.12 181.15,54.12 180.98,53.95 180.98,52.82 180.84,52.68 ; 4 cut-outs
GND on BOTTOM: 167.57,9.83 167.3,10.1 167.3,10.65 166.91,11.03 165.81,11.03 165.36,11.48 165.36,12.61 165.76,13.02 169.48,13.02 169.7,12.8 169.7,10.05 169.47,9.83
GND on BOTTOM: 79.07,9.34 76.91,11.5 76.91,12.52 84.15,12.52 84.4,12.27 84.4,9.59 84.15,9.34
GND on BOTTOM: outline of 239 points within 1.83,0.51 203.3,68.9 ; 21 cut-outs
GND on BOTTOM: 117.78,100.26 117.76,100.28 117.76,103.72 117.79,103.76 117.81,103.75 118.86,103.75 119.11,104 120.04,104 120.92,103.12 121.58,103.12 121.59,103.11 121.98,103.11 122.06,103.03 122.06,102.39 121.96,102.3 121.34,102.3 121.34,102.31 118.99,102.31 118.74,102.06 118.74,100.28 118.72,100.26
GND on BOTTOM: 106.17,89.8 106.09,89.88 106.09,90.05 106.18,90.14 106.55,90.14 106.81,90.41 106.81,90.52 106.45,90.88 106.45,91.33 106.6,91.47 106.79,91.47 106.86,91.4 106.86,90.95 107.1,90.71 107.7,90.71 107.86,90.55 107.86,90.42 107.68,90.24 107.13,90.24 106.69,89.8
GND on BOTTOM: 111.58,138.63 111.33,138.88 111.33,141.29 111.45,141.42 117.29,141.42 117.42,141.29 117.42,139.01 117.04,138.63 ; 4 cut-outs
GND on BOTTOM: 160.6,80.21 160.09,80.71 160.09,82.26 159.74,82.62 157.55,82.62 156.41,83.76 156.41,86.81 156.28,86.94 156.28,88.33 156.41,88.46 160.35,88.46 161.24,87.57 161.24,85.92 161.36,85.79 162.76,85.79 162.89,85.67 162.89,81.48 163.52,80.84 163.52,80.33 163.4,80.21 ; 2 cut-outs
GND on BOTTOM: 84.28,114.3 83.65,114.92 83.65,119.86 83.96,120.17 85.53,120.17 85.85,119.86 85.85,114.36 85.78,114.3
GND on BOTTOM: 124.1,86.17 123.98,86.29 123.98,86.83 124.5,87.34 125.68,87.34 125.85,87.52 125.85,88.26 125.7,88.41 125.7,89.04 125.87,89.21 126.2,89.21 126.57,88.84 126.57,88.23 126.87,87.93 126.87,86.56 126.74,86.43 125.73,86.43 125.42,86.73 124.96,86.73 124.7,86.48 124.7,86.26 124.61,86.17 ; 2 cut-outs
GND on BOTTOM: 152.28,34.23 152.25,34.27 152.25,34.76 152.38,34.9 152.79,34.9 152.94,35.06 152.94,35.97 153.14,36.16 154.66,36.16 154.79,36.02 154.79,35.06 153.96,34.23
GND on BOTTOM: 138.63,12.9 138.5,13.02 138.5,16.32 139.51,17.33 143.68,17.33 143.87,17.15 143.87,13.16 143.61,12.9
GND on BOTTOM: 183.7,118.01 183.65,118.06 183.65,118.79 184.4,119.54 188.3,119.54 188.36,119.47 188.36,119.07 188.24,118.94 187.57,118.94 187.39,118.76 186.97,118.76 186.87,118.66 186.87,118.1 186.78,118.01 ; 3 cut-outs
GND on BOTTOM: 184.86,68.65 184.26,69.25 184.26,92.87 184.49,93.1 188.91,93.1 189.05,92.96 189.05,69.16 188.54,68.65
GND on BOTTOM: 46.84,36.5 46.29,37.04 46.29,40.32 46.25,40.37 46.25,42.46 47.26,43.47 60.54,43.47 60.99,43.02 63.08,43.02 63.85,43.79 63.85,57.03 74.13,67.32 76.41,67.32 79.58,64.14 85.04,64.14 88.26,67.37 98.79,67.37 99.07,67.65 99.07,70.5 100.31,71.75 108.43,71.75 108.86,71.32 108.86,70.2 107.59,68.93 107.59,67.52 108.09,67.03 109.56,67.03 109.75,66.84 109.75,64.66 109.6,64.51 108.2,64.51 108.2,64.5 107.82,64.5 106.19,62.87 106.19,61.44 107.34,60.29 111.22,60.29 111.74,59.78 111.74,56.2 114.11,53.83 114.11,49.77 104.85,40.51 54.91,40.51 50.9,36.5 50.8,36.5 50.8,36.5 ; 3 cut-outs
GND on BOTTOM: 101.55,113.73 101.42,113.86 101.42,115.26 101.55,115.38 103.07,115.38 103.32,115.64 103.32,116.65 103.45,116.78 107.26,116.78 107.64,117.16 107.64,118.56 107.9,118.81 112.21,118.81 112.98,118.05 112.98,115.26 111.45,113.73 ; 1 cut-out
GND on BOTTOM: 127.58,117.92 127.45,118.05 127.45,122.5 127.71,122.75 130.25,122.75 130.38,122.62 130.38,118.05 130.25,117.92 ; 1 cut-out
GND on BOTTOM: outline of 281 points within 0.58,34.3 138.16,157.39 ; 37 cut-outs
GND on BOTTOM: 195.02,75.45 195.02,76.97 196.29,76.97 196.42,76.85 196.42,75.58 196.29,75.45
GND on BOTTOM: 116.7,118.86 115.18,120.38 115.18,121.65 114.64,122.19 114.64,122.74 114.95,123.05 116.19,123.05 116.32,122.92 116.32,121.91 116.57,121.65 117.84,121.65 117.97,121.78 118.48,121.78 118.6,121.65 118.6,119.49 117.97,118.86 ; 4 cut-outs
GND on BOTTOM: 65.35,91.98 65.2,92.12 65.2,97.46 67.13,99.38 70.56,99.38 70.67,99.28 70.67,92.66 69.98,91.98
GND on BOTTOM: 124.03,28.52 123.77,28.77 123.77,33.34 123.9,33.47 127.84,33.47 128.72,32.58 128.72,29.28 127.96,28.52
GND on BOTTOM: 98.49,150.61 98.09,151.01 98.09,153.59 98.22,153.71 100.21,153.71 100.32,153.61 100.32,153.02 100.56,152.77 102.23,152.77 102.39,152.62 102.39,150.61
GND on BOTTOM: 153.87,55.19 153.62,55.44 153.62,56.84 153.74,56.96 158.95,56.96 159.2,57.22 159.2,59.89 159.33,60.01 161.24,60.01 161.24,59.76 161.11,59.63 160.09,59.63 159.97,59.5 159.97,58.23 160.09,58.11 161.11,58.11 161.24,57.98 161.24,57.22 162.17,56.29 162.17,55.45 161.91,55.19
GND on BOTTOM: 92.35,132 91.89,132.45 91.89,135.58 92.02,135.7 95.63,135.7 95.73,135.6 95.73,134.18 93.55,132
GND on BOTTOM: outline of 122 points within 142.75,84.88 203.34,157.39 ; 51 cut-outs
GND on BOTTOM: outline of 154 points within 83.94,89.74 105.71,93.55
GND on BOTTOM: 170,132.59 169.79,132.79 169.79,134.08 170,134.28 175.56,134.28 175.58,134.3 182.29,134.3 182.43,134.16 182.43,132.84 182.19,132.59 ; 10 cut-outs
GND on BOTTOM: 174.93,62.39 174.91,62.41 171.39,62.41 171.18,62.61 171.18,63.33 172.3,64.45 175.35,64.45 175.71,64.09 175.71,62.48 175.62,62.39
GND on BOTTOM: 166.19,110.74 166.06,110.86 166.06,110.99 172.41,117.34 172.41,117.85 172.28,117.98 171.78,117.98 164.92,111.12 164.79,111.12 164.54,111.37 164.54,111.5 172.41,119.37 172.41,119.5 172.03,119.88 171.78,119.88 164.03,112.13 163.78,112.13 163.52,112.39 163.52,112.52 170.38,119.37 170.38,119.5 170,119.88 169.74,119.88 164.03,114.17 163.78,114.17 163.65,114.29 163.65,114.55 168.47,119.37 168.47,119.63 168.22,119.88 167.84,119.88 164.03,116.07 163.78,116.07 163.52,116.33 163.52,116.45 166.57,119.5 166.57,119.88 166.44,120.01 165.93,120.01 164.03,118.1 163.78,118.1 163.52,118.36 163.52,118.48 165.43,120.39 172.28,120.39 172.79,119.88 172.79,112.9 170.63,110.74 170.25,110.74 170.13,110.86 170.13,111.12 172.41,113.4 172.41,113.66 172.03,114.04 171.9,114.04 168.73,110.86 168.35,110.86 168.22,110.99 168.22,111.25 172.54,115.56 172.54,115.69 172.16,116.07 171.9,116.07 166.57,110.74
GND on L2VCC: 74.07,88.65 72.4,90.32 72.4,90.67 72.67,90.94 73.81,90.94 74.7,91.83 78.13,91.83 78.38,92.08 82.42,92.08 82.81,91.68 82.81,91.21 81.66,90.05 77.59,90.05 76.19,88.65
GND on L2VCC: outline of 231 points within 0.51,0.51 203.34,157.39 ; 2 cut-outs
GND on L2VCC: 105.93,89.92 105.93,91.08 105.29,91.71 105.29,95 106.8,95 107.33,94.48 107.33,92.95 108.47,91.81 108.47,90.19 108.2,89.92
GND on L3: 105.22,86.87 87.83,86.87 86.89,85.93 86.89,82.62 87.53,81.97 94.17,81.97 95.9,83.7 103.27,83.7 104.91,82.06 105.26,82.06 105.43,82.23 105.43,86.66
GND on L3: 122.68,66.31 122.68,63.8 125.21,63.8 125.34,63.67 131.03,63.67 131.16,63.8 131.16,66.31 124.73,66.31 124.52,66.52 122.89,66.52
GND on L3: 46.18,55.95 43.51,58.62 43.51,66.5 45.79,68.78 51.09,68.78 51.54,68.33 51.54,59.51 49.42,57.39 49.42,57.37 49.4,57.37 47.99,55.95
GND on L3: 143.59,131.05 152.4,122.24 154.66,122.24 154.96,121.94 154.96,120.69 154.66,120.39 154.66,119.58 154.94,119.3 154.94,116.96 155.78,116.12 159.23,116.12 160.42,114.93 160.42,113.91 160.63,113.71 160.93,113.71 161.08,113.56 161.08,113.12 160.83,112.87 159.74,112.87 159.51,112.64 159.51,112.26 159.31,112.06 158.39,112.06 153.82,116.63 153.82,117.14 153.26,117.7 151.92,117.7 148.99,114.77 148.21,114.77 147.65,115.33 147.65,117.49 148.21,118.05 149.78,118.05 150.26,118.53 150.26,120.34 149.32,121.28 145.51,121.28 144.32,122.47 144.32,125.54 139.13,130.73 139.13,131.52 141.17,133.56 143.23,133.56 143.59,133.2
GND on L3: 109.39,70.76 104.7,70.76 104.38,70.44 104.38,69.99 104.7,69.68 104.7,49.98 106.55,48.13 110.89,48.13 112.17,49.42 112.92,50.17 112.92,55.06 112.5,55.49 112.5,56.29 112.71,56.51 115.62,56.51 116.46,55.67 116.46,49.98 116.88,49.56 117.58,49.56 119.39,51.37 119.39,56.46 118.19,57.66 118.19,64.09 113.76,68.52 111.63,68.52
GND on L3: 101.27,107.05 101.27,102.3 101.53,102.04 104.56,102.04 104.82,102.3 104.82,107.05 104.56,107.32 101.53,107.32
GND on L3: outline of 248 points within 0.51,0.51 203.34,157.39 ; 2 cut-outs
GND on L4: 122.68,66.31 122.68,63.8 124.72,63.8 124.9,63.62 126.57,63.62 126.75,63.8 131.16,63.8 131.16,66.31 124.87,66.31 124.7,66.49 122.85,66.49
GND on L4: outline of 90 points within 27.76,0.51 199.52,57
GND on L4: 3.02,15.89 3.02,17.69 12.6,17.69 13.57,18.44 13.11,19.57 13.11,30.63 13.57,31.76 12.6,32.51 3.02,32.51 3.02,33.5 2.72,34.21 2.01,34.51 0.51,34.51 0.51,35.32 0.98,35.79 3.39,35.79 3.76,35.29 4.35,35.09 8.6,35.09 9.02,34.7 9.58,34.6 10.22,34.93 10.48,35.6 10.48,37.14 13.97,37.14 14.97,38.15 13.97,39.15 10.48,39.15 10.48,47.05 13.97,47.05 14.97,48.06 13.97,49.06 10.48,49.06 10.48,50.6 9.73,51.57 8.6,51.11 4.35,51.11 3.82,50.96 3.45,50.55 3.39,50.41 3.34,50.41 3.34,50.84 3.02,50.51 0.89,50.51 0.61,50.79 0.61,51.73 0.68,51.81 1.65,51.81 2.33,52.49 2.33,53.64 2.49,53.79 10.75,53.79 10.75,53.79 10.9,53.79 10.9,53.64 16.15,48.39 16.15,48.33 17.09,47.39 17.09,46.17 21.92,41.34 21.92,23.94 23.85,22.01 24.08,22.01 24.52,21.58 24.52,14.38 22.21,12.07 17.68,12.07 13.87,15.89
GND on L4: 33.87,89.83 36.32,87.37 36.32,85.96 34.63,84.27 30.81,84.27 28.38,86.7 23.71,86.7 22.43,85.41 19.76,85.41 18.74,86.43 15.06,86.43 14.17,87.32 14.17,89.48 15.95,91.25 20.52,91.25 21.94,89.83
GND on L4: 54.12,91.47 57.95,91.47 58.4,91.02 58.4,90.11 53.04,84.76 52.55,84.76 52.24,85.07 50.98,85.07 50.36,84.45 48.04,84.45 47.7,84.79 47.7,85.32 48.3,85.91 50.1,85.91 50.74,86.56 50.74,88.09
GND on L4: outline of 165 points within 0.51,65.3 203.19,157.39
GND on L4: outline of 108 points within 93.19,48.04 119.89,79.37
GND on L4: 40.78,55.61 42.84,57.67 42.84,62.65 43.01,62.83 43.01,62.84 48.46,62.84 50.33,64.72 51.48,64.72 51.79,64.4 51.79,59.73 42.9,50.84 41.2,50.84 40.78,51.26
GND on L4: 101.27,106.88 101.27,102.3 101.47,102.1 104.62,102.1 104.82,102.3 104.82,107.05 104.52,107.36 101.75,107.36
GND on L4: 50.84,42.9 50.84,31.32 50.1,30.57 50.1,28.28 49.81,28 48.46,28 48.21,28.25 48.21,29.91 45.49,32.63 45.49,41.64 47.01,43.16 50.58,43.16
GND on L5GND: outline of 231 points within 0.51,0.51 203.34,157.39
VCC1R05VIDEO_PEX_PLLVDD on TOP: 161.2,114.56 161.11,114.65 161.11,115.97 160.93,116.15 160.68,116.15 160.6,116.22 160.6,117.01 160.68,117.09 161.11,117.09 161.36,117.34 162.76,117.34 163.01,117.09 163.01,114.72 162.85,114.56 ; 3 cut-outs
VCC_CORE on TOP: 84.21,79.7 83.6,80.31 73.65,80.31 73.1,80.86 73.1,81.73 72.84,81.98 71.02,81.98 70.39,82.62 69.8,82.62 69.67,82.75 69.67,101.6 81.99,113.92 84.71,113.92 85.52,114.72 85.52,121.28 86.48,122.24 93.29,122.24 93.31,122.22 94.81,122.22 95.09,121.95 95.09,116.84 95.69,116.24 95.69,106.87 93.93,105.11 93.93,101.8 95.2,100.53 103.45,100.53 103.62,100.35 103.62,97.49 102.73,96.59 102.73,94.49 102.73,94.49 102.73,91.1 102.56,90.94 102.56,87.57 102.18,87.19 86.94,87.19 86.56,86.81 86.56,80.59 85.67,79.7 ; 1 cut-out
VCC_CORE on BOTTOM: outline of 178 points within 83.03,78.87 106.5,91.88
VCC_CORE on BOTTOM: 71.21,91.91 70.89,92.23 70.89,102.63 82.22,113.97 85.48,113.97 85.92,114.4 85.92,120.88 87.16,122.12 92.02,122.12 92.4,121.73 92.4,120.21 91.77,119.58 91.77,117.04 92.6,116.2 92.6,102.99 92.61,102.99 92.61,102.86 93.04,102.43 93.16,102.43 94.08,101.52 94.08,98.01 93.29,97.22 93.29,96.44 93.06,96.21 92.78,96.21 92.53,96.46 92.53,97.3 89.53,100.29 89.51,100.29 88.79,101.01 87.47,101.01 85.67,102.81 84.02,102.81 83.26,103.57 82.5,103.57 81.73,102.81 81.73,101.29 81.48,101.03 78.94,101.03 77.92,100.02 76.78,100.02 76.53,99.76 76.53,99.13 76.4,99 76.4,98.49 74.88,96.97 74.88,93.79 72.99,91.91 ; 2 cut-outs
VCC_CORE on BOTTOM: 70.18,82.05 69.92,82.3 69.92,84.09 70.02,84.19 72.66,84.19 72.84,84.01 72.84,82.69 72.2,82.05
VCC_CORE on L2VCC: 82.83,81.54 82.45,81.92 68.22,81.92 67.83,82.32 67.83,100.32 84.97,117.46 84.97,121.66 85.37,122.05 94.61,122.05 94.75,121.91 94.75,106.57 93.48,105.3 93.48,100.95 94.61,99.83 104.91,99.83 104.91,91.56 105.55,90.92 105.55,87.25 88.77,87.25 87.51,86 87.51,82.19 86.86,81.54 ; 1 cut-out
VCC_CORE on L3: 83,82.92 83,83.38 82.24,84.14 82.24,94.43 80.59,96.08 80.59,100.46 78.75,102.3 78.75,102.75 78.69,102.81 78.73,102.85 78.73,104.04 79.8,105.12 79.8,109.75 84.48,114.43 84.48,121.02 85.69,122.23 94.81,122.23 94.94,122.1 94.94,117 95.69,116.25 95.69,106.87 94.31,105.5 94.31,101.8 96.21,99.89 103.32,99.89 105.36,97.86 105.36,91.64 105.53,91.46 105.53,88.78 105.47,88.71 105.36,88.71 105.36,87.7 105.48,87.57 105.48,87.32 105.36,87.19 87.45,87.19 86.56,86.3 86.56,83 86.27,82.71 83.86,82.71 83.82,82.75 83.17,82.75
VCC_CORE on L4: 89.86,91.64 105.36,91.64 105.74,91.25 105.74,87.57 105.36,87.19 87.45,87.19 86.56,86.3 86.56,81.6 86.31,81.35 83.13,81.35 83,81.48 83,83.38 82.37,84.02 82.37,84.78 84.02,86.43 84.66,86.43 87.96,89.73 88.85,89.73 89.1,89.98 89.1,90.87
VCC_CORE on L4: 84.48,114.43 84.48,121.02 85.68,122.23 94.8,122.23 94.94,122.1 94.94,117.02 95.68,116.28 95.68,111.45 92.61,108.38 80.08,108.38 79.89,108.57 79.89,109.85
VDD10 on TOP: 39.28,57.14 38.74,57.68 38.74,58.09 39.06,58.41 42.17,58.41 42.55,58.79 42.55,62.72 42.17,63.11 40.64,63.11 40.58,63.18 40.58,65.45 40.64,65.52 40.64,66.04 40.97,66.36 42.13,66.36 42.13,66.34 42.44,66.03 42.44,64.88 44.2,63.12 44.2,58.74 42.6,57.14 ; 12 cut-outs
VDD10 on BOTTOM: 44.69,64.87 44.54,65.02 44.54,66.48 44.66,66.6 50.28,66.6 50.51,66.37 50.51,65.55 50.2,65.24 47.53,65.24 47.17,64.87 ; 2 cut-outs
VDD10 on L4: 40.57,63.59 41.8,63.59 42.24,63.15 48.46,63.15 50.61,65.3 50.61,65.92 50.17,66.36 48.7,66.36 47.4,65.05 40.57,65.05 40.34,64.83 40.34,63.82
VDD_DAC_33 on TOP: 13.76,81.54 13.75,81.56 13.75,82.26 13.28,82.72 13.28,83.38 13.71,83.81 13.71,84.29 13.54,84.47 12.95,84.47 12.79,84.64 12.79,85.41 12.77,85.41 12.52,85.67 12.01,85.67 11.88,85.79 11.88,86.43 12.14,86.68 13.15,86.68 14.67,85.17 14.67,81.56 14.64,81.54 ; 1 cut-out
VDD_DAC_33 on BOTTOM: 13.91,80.92 13.85,80.98 13.85,81.61 13.85,81.62 13.85,81.86 13.29,82.43 13.29,83.33 13.66,83.71 14.35,83.71 14.68,83.38 14.68,82.18 14.63,82.13 14.63,80.95 14.6,80.92 ; 2 cut-outs
VDDREG on BOTTOM: 41.28,63.61 41.09,63.8 41.09,66.51 41.2,66.61 44.2,66.61 44.35,66.46 44.35,65.73 44.25,65.63 42.66,65.63 42.41,65.37 42.41,64.29 41.73,63.61 ; 1 cut-out
0D675V_S0 on TOP: 108.4,18.1 108.4,19.85 110.47,21.92 111.35,21.92 111.66,22.23 111.66,29.51 111.81,29.66 113.54,29.66 113.61,29.58 113.61,27.55 113.23,27.17 113.23,22.48 113.22,22.47 113.22,21.73 112.19,20.69 111.45,20.69 110.25,19.5 110.25,18.39 109.96,18.1 ; 4 cut-outs
0D675V_S0 on BOTTOM: 113.43,21.86 113.38,21.91 113.38,23.72 113.23,23.87 112.11,23.87 111.96,24.02 111.96,24.63 112.16,24.83 113.69,24.83 114.2,24.33 114.2,21.94 114.12,21.86
0D675V_S0 on BOTTOM: 112.98,28.95 112.85,29.07 112.85,29.51 113.1,29.76 113.1,31.72 113.18,31.79 113.54,31.79 113.99,31.34 113.99,29.3 113.64,28.95
1D05S_VCCST on TOP: 105.52,81.86 105.62,81.95 105.62,82.62 105.77,82.77 106.25,82.77 106.41,82.92 107.92,82.92 107.96,82.88 107.96,81.35 107.92,81.31 107.05,81.31 106.99,81.37 106.67,81.37 106.45,81.16 106.45,80.41 106.37,80.32 105.42,80.32 105.31,80.22 105.31,80.03 105.23,79.95 104.85,79.95 104.72,80.08 104.72,81.48 105.1,81.86 ; 1 cut-out
1D05S_VCCST on BOTTOM: 65.28,86.37 64.67,86.97 64.67,87.46 68.15,90.94 69.8,90.94 70.05,90.68 70.05,87.24 70.15,87.14 70.15,87.14 70.21,87.09 72.79,87.09 72.87,87.17 72.87,87.66 72.97,87.76 73.48,87.76 73.61,87.64 73.61,86.48 73.49,86.37 ; 2 cut-outs
1D05S_VCCST on BOTTOM: 71.17,78.42 70.77,78.82 70.77,81.48 70.96,81.67 70.97,81.67 71.04,81.74 72.18,81.74 72.85,82.4 73.11,82.4 73.98,82.4 74.1,82.29 74.1,80.26 74,80.15 72.61,80.15 72.28,79.83 72.28,79.31 72.5,79.09 72.82,79.09 72.92,79.19 73.99,79.19 74.09,79.09 74.09,78.48 74.03,78.42 ; 2 cut-outs
1D05V_HSIO on TOP: 118.78,99.57 118.71,99.65 118.71,101.47 118.83,101.58 120.22,101.58 120.22,101.57 120.66,101.57 120.75,101.49 120.75,101.06 120.75,101.05 120.75,99.71 120.61,99.57
1D05V_HSIO on BOTTOM: 117.46,104.08 117.3,104.24 117.3,105.02 117.14,105.18 115.85,105.18 115.64,104.98 115.64,104.6 115.24,104.2 113.93,104.2 113.74,104.39 113.74,104.97 113.99,105.22 113.99,106.88 114.75,107.64 119.74,107.64 120.03,107.35 120.73,107.35 121.02,107.64 127.2,107.64 127.33,107.51 127.33,106.24 127.07,105.99 122.21,105.99 121.85,105.63 120.46,105.63 120.09,105.26 120.09,104.46 119.71,104.08 ; 2 cut-outs
1D05V_HSIO on L4: 116.38,100.65 120.27,100.65 120.47,100.85 120.47,101.67 120.27,101.88 119.36,101.88 119.15,102.08 119.15,102.31 118.66,102.8 118.66,103.49 118.98,103.81 119.55,103.81 120.02,104.27 120.02,104.82 119.81,105.03 116.37,105.03 116.19,104.85 116.19,100.84
1D05V_PWR on BOTTOM: 128.75,101.52 128.72,101.54 128.72,106.11 128.22,106.62 128.22,107 128.47,107.26 128.47,108.15 128.66,108.33 128.66,111.14 128.92,111.41 133.06,111.41 133.37,111.1 133.37,102.05 132.84,101.52 ; 2 cut-outs
1D5V_PWR on BOTTOM: 114.48,107.7 114.4,107.78 114.4,110.08 114.53,110.2 115.29,110.2 115.54,110.46 115.54,110.66 115.57,110.69 116.99,110.69 117.07,110.61 117.07,109.31 116.84,109.08 115.26,109.08 115.22,109.04 115.22,107.81 115.11,107.7 ; 1 cut-out
1D05V_S0 on TOP: 116.87,99.59 116.79,99.67 116.79,102.3 116.66,102.43 116.15,102.43 116.02,102.56 116.02,104.08 115.64,104.46 113.99,104.46 113.74,104.72 113.74,105.35 113.36,105.73 111.96,105.73 111.45,105.22 111.45,104.08 111.33,103.95 110.82,103.95 110.69,104.08 110.69,106.37 110.11,106.95 107.8,106.95 107.64,107.1 107.64,107.99 107.54,108.09 106.35,108.09 106.25,107.99 106.25,107.87 106.14,107.76 104.85,107.76 104.72,107.89 104.72,108.91 105.23,109.42 107.77,109.42 108.94,108.25 112.67,108.25 113.2,108.78 124.89,108.78 127.81,105.86 127.84,105.86 127.84,101.75 127.34,101.25 124.95,101.25 123.99,100.3 122.64,100.3 122.49,100.15 121.1,100.15 120.98,100.28 120.98,101.54 120.8,101.72 118.81,101.72 118.57,101.48 118.57,101.35 118.58,101.35 118.58,99.7 118.48,99.59 ; 6 cut-outs
1D05V_S0 on TOP: 108.46,78.6 108.13,78.93 107.62,78.93 107.36,78.67 105.39,78.67 105.3,78.75 105.3,79.71 105.49,79.9 105.49,79.9 105.6,80 107.04,80 107.2,79.84 108.77,79.84 109.06,80.13 110.77,80.13 110.86,80.05 111.19,80.05 111.62,80.48 111.96,80.48 112.1,80.35 112.1,80.12 111.7,79.72 111.7,79.47 111.71,79.46 111.71,78.7 111.61,78.6
1D05V_S0 on TOP: 149.11,121.56 148.87,121.8 148.16,121.8 148.09,121.8 147.93,121.96 147.93,122.9 148.5,123.46 149.33,123.46 150.25,122.54 150.25,121.58 150.23,121.56 ; 1 cut-out
1D5V_S0 on BOTTOM: 113.7,107.56 113.65,107.62 113.65,110.13 113.68,110.16 114.1,110.16 114.2,110.06 114.2,109.58 114.13,109.51 114.13,108.47 114.24,108.36 114.24,107.68 114.12,107.56
1D05V_S0 on BOTTOM: 124.66,98.75 123.38,100.03 123.38,100.89 123.24,101.03 123.24,102.33 123.42,102.52 124.23,102.52 124.46,102.29 124.46,101.51 124.46,101.51 124.46,101.43 124.74,101.15 125.37,101.15 125.42,101.2 125.42,101.73 125.8,102.11 125.8,102.82 125.56,103.07 125.56,103.31 125.45,103.42 125.45,105.34 125.45,105.34 125.45,105.68 125.65,105.88 127.73,105.88 127.84,105.98 128.33,105.98 128.4,105.92 128.4,101.41 128.09,101.11 128.09,100.02 127.96,99.89 127.71,99.89 126.57,98.75 ; 3 cut-outs
1D05V_S0 on BOTTOM: 109.04,78.57 108.89,78.72 108.89,79.15 109.01,79.28 109.01,79.63 108.92,79.73 108.92,80.15 109.02,80.24 109.48,80.24 109.51,80.21 109.51,79.7 109.34,79.53 109.34,79.25 109.42,79.18 110.51,79.18 110.67,79.33 110.67,79.53 110.44,79.76 110.44,80.07 110.51,80.14 110.77,80.14 110.97,79.94 110.97,79.25 111.07,79.15 111.35,79.15 111.48,79.28 111.48,80.09 111.76,80.37 111.99,80.37 112.09,80.27 112.09,80.07 111.81,79.79 111.81,78.85 111.53,78.57
