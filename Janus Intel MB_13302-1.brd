# Allegro board Janus Intel MB_13302-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQS4: length 65.6
  TOP w0.127: v2(102.8,28.5) 103.12,28.82 v1(103.27,28.82)
  L3 w0.114: v1(79.58,67.71) 79.58,66.93 78.6,65.95 78.6,64.68 80.42,62.86 80.42,61.49 89.56,52.35 90.66,51.25 90.8,51.11 90.8,50.95 90.37,50.51 90.37,50.16 90.71,49.82 91.06,49.82 91.5,50.26 91.66,50.26 91.86,50.05 91.86,49.89 91.43,49.45 91.43,49.1 91.77,48.76 92.12,48.76 92.56,49.2 92.72,49.2 92.92,48.99 92.92,48.83 92.49,48.39 92.49,48.04 92.83,47.7 93.18,47.7 93.62,48.13 93.78,48.13 93.99,47.93 93.99,47.77 93.55,47.33 93.55,46.86 93.85,46.57 94.2,46.57 94.4,46.78 94.58,46.78 94.77,46.59 94.77,46.41 94.57,46.2 94.57,45.85 102.84,37.58 102.84,29.26 v1(103.27,28.82)
  BOTTOM w0.089: CPU1.AW57 83.92,71.85 83.92,71.65 83.89,71.56 83.85,71.47 83.85,71.35 83.93,71.17 83.93,70.84 83.6,70.5 83.6,70.05 82.53,68.98 82.37,68.98 82.18,68.98 80.83,67.63 79.66,67.63 v1(79.58,67.71)
  BOTTOM w0.127: DM1.171 103.65,30 103.72,29.94 103.72,29.27 v1(103.27,28.82)
M_A_DQS5: length 62.6
  TOP w0.127: v2(64.33,28.47) 63.97,28.82 v1(63.85,28.82)
  L4 w0.114: v1(85.58,68.4) 85.48,68.4 85.13,68.75 84.51,68.75 83.21,67.46 82.94,67.46 79.9,64.43 79.9,60.51 74.24,54.84 74.24,53.4 74.12,53.28 73.96,53.28 73.49,53.75 73.14,53.75 72.8,53.41 72.8,53.06 73.27,52.59 73.27,52.43 73.06,52.22 72.9,52.22 72.43,52.69 72.08,52.69 71.74,52.35 71.74,51.99 72.2,51.53 72.2,51.37 72,51.16 71.84,51.16 71.37,51.63 71.02,51.63 70.68,51.28 70.68,50.93 71.14,50.47 71.14,50.31 62.92,42.09 62.92,32.36 63.41,31.87 63.41,29.26 v1(63.85,28.82)
  BOTTOM w0.089: v1(85.58,68.4) 85.58,68.75 85.68,68.86 85.68,69.11 86.09,69.52 86.09,70.36 86.36,70.63 86.36,71.17 86.28,71.35 86.28,71.47 86.32,71.56 86.35,71.65 86.35,71.85 CPU1.AW53
  BOTTOM w0.127: v1(63.85,28.82) 64.29,29.27 64.29,29.64 64.05,29.88 DM1.47
M_A_DQS6: length 71
  TOP w0.127: v2(69.09,25.11) 68.79,24.82 v1(68.55,24.82)
  L4 w0.089: v1(93.45,76.57) 93.06,76.18 93.06,75.6 92.66,75.2 92.17,75.2 91.77,74.8 91.77,74.37 91.31,73.91 91.14,73.91 91.12,73.89 91.1,73.89
  L4 w0.114: v1(68.55,24.82) 68.11,25.25 68.11,25.87 68.38,26.14 68.38,39.42 73.21,44.24 73.21,44.6 72.85,44.96 72.85,45.14 73.04,45.33 73.21,45.33 73.58,44.96 73.93,44.96 74.27,45.3 74.27,45.66 73.81,46.12 73.81,46.28 74.02,46.49 74.18,46.49 74.64,46.03 74.99,46.03 75.33,46.37 75.33,46.72 74.87,47.18 74.87,47.34 75.08,47.55 75.24,47.55 75.7,47.09 76.05,47.09 76.36,47.4 76.36,48.84 85.67,58.15 85.67,65.45 89.72,69.49 89.72,72.61 91,73.89 91.1,73.89
  BOTTOM w0.127: v1(93.45,76.57) 93.68,76.8 CPU1.AL42 ; DM1.64 69.15,23.66 69.01,23.8 69.01,24.35 v1(68.55,24.82)
M_A_DQS7: length 69.3
  TOP w0.127: v1(107.54,25.45) 107.69,25.45 v2(108.02,25.78)
  L3 w0.089: 89.65,71.24 89.65,71.26 89.67,71.28 89.67,72.77 88.99,73.46 88.99,74.75 89.03,74.79 89.03,76.16 v1(88.7,76.5)
  L3 w0.114: v1(107.54,25.45) 107.78,25.45 108.1,25.77 108.1,26.32 108.35,26.57 108.61,26.57 108.74,26.7 108.74,26.96 108.61,27.09 108.35,27.09 108.1,27.34 108.1,42.17 105.73,44.55 105.57,44.55 105.09,44.07 104.74,44.07 104.4,44.41 104.4,44.76 104.87,45.24 104.87,45.4 104.67,45.61 104.5,45.61 104.03,45.13 103.68,45.13 103.34,45.47 103.34,45.82 103.81,46.3 103.81,46.46 103.61,46.67 103.44,46.67 102.97,46.19 102.62,46.19 90.33,58.48 90.33,70.14 89.65,70.82 89.65,71.24
  BOTTOM w0.127: CPU1.AL49 88.99,76.8 v1(88.7,76.5) ; v1(107.54,25.45) 108.56,24.43 108.56,23.9 108.75,23.71 DM1.188
M_A_DQS#0: length 82.6
  TOP w0.127: v1(92.85,29.46) v2(92.85,30.02)
  L3 w0.114: v1(74.19,76.99) 73.75,76.99 72.61,75.85 68.66,75.85 67.06,74.25 67.06,66.65 67.18,66.53 67.45,66.53 67.58,66.65 67.58,69.21 67.84,69.47 68.3,69.47 68.56,69.21 68.56,66.09 68.07,65.61 68.07,58.62 92.3,34.4 92.3,29.3 92.39,29.2 92.59,29.2 v1(92.85,29.46)
  BOTTOM w0.089: CPU1.AJ61 81.68,77.76 81.29,78.15 80.86,78.15 80.81,78.17 80.68,78.22 80.48,78.22 80.33,78.15 77.5,78.15 77.4,78.25 77.07,78.25 77.04,78.27 77.02,78.27
  BOTTOM w0.127: 77.02,78.27 75.28,78.27 74.98,77.97 74.34,77.97 74.08,77.71 74.08,77.1 v1(74.19,76.99) ; v1(92.85,29.46) 93.05,29.46 93.21,29.62 93.21,29.81 92.85,30.17 DM1.135
M_A_DQS#1: length 73.8
  TOP w0.127: v1(53.55,24.82) 53.68,24.82 v2(54.13,25.26)
  L4 w0.114: v1(53.55,24.82) 53.29,24.55 52.98,24.55 52.85,24.68 52.85,26.56 53.5,27.2 53.5,29.84 53.31,30.03 53.31,48.52 57.54,52.76 57.54,53.11 57.07,53.57 57.07,53.73 57.28,53.94 57.44,53.94 57.91,53.48 58.26,53.48 58.6,53.82 58.6,54.17 58.13,54.63 58.13,54.79 58.34,55 58.5,55 58.97,54.54 59.32,54.54 59.61,54.82 59.61,56.26 70.17,66.82 70.17,67.66 74.16,71.65 74.16,72.71 75.3,73.85 77.52,73.85 78.14,74.46 78.67,74.46 78.75,74.54 78.75,74.73 v1(78.44,75.04)
  BOTTOM w0.089: CPU1.AN62 81.03,75.54 80.83,75.54 80.74,75.58 80.65,75.62 80.53,75.62 80.4,75.55 80.37,75.54 80.22,75.49 78.36,75.49 78.26,75.38 78.26,75.22 v1(78.44,75.04)
  BOTTOM w0.127: v1(53.55,24.82) 52.95,24.22 DM1.10
M_A_DQS#2: length 75.1
  TOP w0.127: v1(97.95,24.18) v2(97.95,23.58)
  L3 w0.114: v1(83.03,75.81) 83.02,75.81 82.8,75.58 81.83,75.58 81.3,75.06 81.3,74.2 79.35,72.25 78.27,72.25 73.09,67.07 73.09,61.03 88.92,45.19 88.92,43.76 89.19,43.49 89.54,43.49 90.01,43.95 90.17,43.95 90.37,43.74 90.37,43.58 89.91,43.12 89.91,42.77 90.25,42.43 90.6,42.43 91.07,42.89 91.23,42.89 91.44,42.68 91.44,42.52 90.97,42.06 90.97,41.71 91.31,41.37 91.67,41.37 92.13,41.83 92.29,41.83 92.5,41.62 92.5,41.46 92.03,41 92.03,40.65 97.62,35.06 97.62,27.14 97.24,26.76 97.24,25.03 97.51,24.76 97.51,24.62 v1(97.95,24.18)
  BOTTOM w0.127: CPU1.AM58 83.15,75.81 v1(83.03,75.81) ; DM1.152 97.95,24.18 v1(97.95,24.18)
M_A_DQS#3: length 68.4
  TOP w0.127: v1(58.42,29.46) v2(58.42,30.09)
  L4 w0.089: 81.12,71.6 81.14,71.6 81.16,71.62 82.59,71.62 83.17,72.2 83.9,72.2 84.28,72.2 85.47,73.4 85.47,76.07 85.37,76.17 85.22,76.17 84.94,75.89 v1(84.94,75.82)
  L4 w0.114: v1(58.42,29.46) 58.21,29.67 58.21,32.02 58.67,32.47 58.67,34.63 58.21,35.08 58.21,44.96 61.93,48.68 61.93,50.84 66.92,55.83 69.04,55.83 69.52,56.3 69.52,56.66 68.87,57.3 68.87,57.48 69.06,57.67 69.24,57.67 69.89,57.02 70.24,57.02 70.58,57.37 70.58,57.72 70.22,58.08 70.22,58.26 70.41,58.45 70.59,58.45 70.95,58.09 71.3,58.09 75.62,62.41 75.62,66.35 80.87,71.6 81.12,71.6
  BOTTOM w0.127: DM1.27 58.05,29.76 58.35,29.46 v1(58.42,29.46) ; v1(84.94,75.82) 84.99,75.77 85.16,75.77 85.33,75.95 CPU1.AM55
M_A_DQS#4: length 65.8
  TOP w0.127: v1(103.27,29.46) v2(103.27,30.02)
  L3 w0.114: v1(103.27,29.46) 103.06,29.67 103.06,37.68 94.79,45.95 94.79,46.11 95,46.31 95,46.68 94.68,47 94.31,47 94.1,46.8 93.94,46.8 93.78,46.96 93.78,47.24 94.21,47.67 94.21,48.02 93.87,48.36 93.52,48.36 93.09,47.93 92.93,47.93 92.72,48.14 92.72,48.3 93.15,48.73 93.15,49.08 92.81,49.42 92.46,49.42 92.03,48.99 91.87,48.99 91.66,49.2 91.66,49.36 92.09,49.79 92.09,50.14 91.75,50.48 91.4,50.48 90.97,50.05 90.81,50.05 90.6,50.26 90.6,50.42 91.03,50.85 91.03,51.2 80.65,61.59 80.65,62.96 78.83,64.78 78.83,65.86 79.81,66.84 79.81,67.31 80.11,67.61 80.3,67.61 80.43,67.73 80.43,68.03 80.3,68.16 v1(80.03,68.16)
  BOTTOM w0.089: v1(80.03,68.16) 79.96,68.08 79.96,67.95 80.08,67.82 80.75,67.82 82.1,69.17 82.45,69.17 83.41,70.13 83.41,70.58 83.74,70.91 83.74,71.15 83.67,71.3 83.67,71.5 83.72,71.63 83.74,71.68 83.74,72.56 83.92,72.74 84.11,72.74 CPU1.AV57
  BOTTOM w0.127: DM1.169 103.05,30.26 103.48,29.84 103.48,29.66 v1(103.27,29.46)
M_A_DQS#5: length 63
  TOP w0.127: v1(63.85,29.46) v2(63.85,30.09)
  L4 w0.114: v1(84.99,67.8) 85.16,67.98 85.16,68.39 85.03,68.52 84.6,68.52 83.31,67.23 83.03,67.23 80.13,64.33 80.13,60.41 74.47,54.75 74.47,53.31 74.21,53.06 73.86,53.06 73.4,53.52 73.24,53.52 73.03,53.31 73.03,53.15 73.49,52.69 73.49,52.34 73.15,52 72.8,52 72.34,52.46 72.18,52.46 71.97,52.25 71.97,52.09 72.43,51.63 72.43,51.28 72.09,50.93 71.74,50.93 71.28,51.4 71.12,51.4 70.91,51.19 70.91,51.03 71.37,50.57 71.37,50.21 63.15,41.99 63.15,32.45 63.64,31.97 63.64,29.67 v1(63.85,29.46)
  BOTTOM w0.089: v1(84.99,67.8) 84.75,67.8 84.63,67.92 84.63,68.07 85.49,68.93 85.49,69.19 85.9,69.6 85.9,70.44 86.17,70.71 86.17,71.15 86.1,71.3 86.1,71.5 86.15,71.63 86.17,71.68 86.17,72.11 86.56,72.5 CPU1.AV53
  BOTTOM w0.127: DM1.45 63.45,29.55 63.54,29.46 v1(63.85,29.46)
M_A_DQS#6: length 71.2
  TOP w0.127: v2(69.14,23.87) 68.82,24.18 v1(68.55,24.18)
  L4 w0.089: v1(92.48,76.55) 92.81,76.55 92.87,76.49 92.87,75.68 92.58,75.39 92.09,75.39 91.58,74.88 91.58,74.45 91.23,74.1 91.14,74.1 91.12,74.12 91.1,74.12
  L4 w0.114: v1(68.55,24.18) 68.11,24.62 68.11,24.93 67.88,25.16 67.88,25.97 68.15,26.24 68.15,39.51 72.98,44.34 72.98,44.5 72.62,44.86 72.62,45.23 72.94,45.55 73.31,45.55 73.67,45.19 73.83,45.19 74.04,45.4 74.04,45.56 73.58,46.02 73.58,46.37 73.92,46.71 74.27,46.71 74.73,46.25 74.89,46.25 75.1,46.46 75.1,46.62 74.64,47.08 74.64,47.43 74.98,47.77 75.33,47.77 75.79,47.31 75.95,47.31 76.14,47.5 76.14,48.93 85.45,58.24 85.45,65.55 89.49,69.59 89.49,72.7 90.91,74.12 91.1,74.12
  BOTTOM w0.127: DM1.62 v1(68.55,24.18) ; v1(92.48,76.55) 92.73,76.8 CPU1.AL43
M_A_DQS#7: length 69.6
  TOP w0.127: v1(107.54,24.82) 107.69,24.82 v2(108.02,24.49)
  L3 w0.089: 89.88,71.24 89.88,71.26 89.86,71.28 89.86,72.85 89.18,73.54 89.18,74.67 89.22,74.71 89.22,76.47 89.32,76.57 89.55,76.57 v1(89.65,76.47)
  L3 w0.114: 89.88,71.24 89.88,70.91 90.56,70.24 90.56,58.58 102.71,46.42 102.88,46.42 103.35,46.9 103.7,46.9 104.04,46.55 104.04,46.2 103.57,45.73 103.57,45.57 103.77,45.36 103.94,45.36 104.41,45.83 104.76,45.83 105.1,45.49 105.1,45.14 104.63,44.67 104.63,44.51 104.83,44.3 105,44.3 105.47,44.77 105.82,44.77 108.33,42.27 108.33,27.43 108.44,27.32 108.71,27.32 108.97,27.06 108.97,26.6 108.71,26.34 108.44,26.34 108.33,26.23 108.33,25.68 107.98,25.33 107.98,25.27 107.54,24.83 v1(107.54,24.82)
  BOTTOM w0.127: CPU1.AL48 89.97,76.8 v1(89.65,76.47) ; DM1.186 108.15,23.69 108.32,23.85 108.32,24.33 107.83,24.82 v1(107.54,24.82)
M_A_RAS#: length 59
  TOP w0.216: v1(85.35,24.18) 85.37,24.16 v2(85.37,23.61)
  L4 w0.216: v1(98.47,70.74) 99.02,70.74 101.22,68.54 101.22,46.1 98.14,43.03 98.14,41.36 92.9,36.12 91.38,36.12 88.32,33.06 88.32,32.16 86.66,30.5 86.66,27.73 86.88,27.52 87.12,27.52 87.32,27.31 87.32,26.85 87.12,26.65 86.88,26.65 86.66,26.43 86.66,25.29 85.55,24.18 v1(85.35,24.18)
  BOTTOM w0.216: DM1.110 v1(85.35,24.18) ; CPU1.AY34 98.82,71.09 v1(98.47,70.74)
M_A_WE#: length 60.6
  TOP w0.216: v1(88.41,26.92) 88.67,26.92 v2(88.92,27.17)
  L4 w0.216: v1(88.41,26.92) 88.35,26.92 87.92,27.35 87.92,27.8 87.26,28.45 87.26,30.29 88.81,31.84 89.43,31.84 89.72,32.12 89.72,33.64 91.62,35.54 93.14,35.54 98.71,41.12 98.71,42.79 101.79,45.87 101.79,68.94 101.06,69.67 101.06,70.23 100.78,70.51 100.06,70.51 99.16,71.41 v1(98.47,71.41)
  BOTTOM w0.216: v1(98.47,71.41) 98.8,71.74 CPU1.AW34 ; v1(88.41,26.92) 88.28,26.92 86.25,28.95 DM1.113
M_VREF_CA_DIMMA: length 79.2
  TOP w1.016: v3(65.34,20.5) 64.02,21.82 51.76,21.82 50.25,23.33 50.25,25.88 51.75,27.39 51.75,30.52 53.61,32.38 59.29,32.38 60.78,33.87 60.78,35.2 ; 64.05,49.7 62.93,49.7 60.63,47.41 60.63,37.54
  L3 w1.016: v3(90.12,24.33) 90.12,24.07 89.61,23.56 89.58,23.56 88.68,22.66 70.59,22.66 67.39,19.45 66.2,19.45 65.48,20.17 65.48,20.36 v3(65.34,20.5)
  BOTTOM w0.33: v3(90.12,24.33) 90.15,24.29 DM1.126
  vias: v2(67.16,50.59)
M_VREF_DQ_DIMMA: length 18.1
  TOP w0.508: 64.56,51.56 R3709.1
  TOP w0.762: 64.56,51.56 63.23,51.56 58.21,46.54 58.21,37.63
  vias: v2(51.08,35.42) v3(49.58,29.38)
MCP_GPIO11: length 18.6
  BOTTOM w0.089: CPU1.AN2 118.53,75.54 119.1,75.54 119.21,75.43 119.24,75.39 119.37,75.39
  BOTTOM w0.102: 119.37,75.39 120.79,75.39 120.86,75.32 121.88,75.32 121.91,75.28 122.6,75.28 123.04,75.72 125.73,75.72 127.03,77.03 v2(127.03,77.26) 127.03,78.18 126.93,78.28 126.93,80.02 126.95,80.04 127.17,80.26 128.74,80.26 131.01,80.26 131.47,79.81 RN1809.5
MCP_GPIO12: length 24.4
  TOP w0.102: v2(116.13,76.34) 115.82,76.34 v1(115.55,76.62)
  L4 w0.102: v1(132.08,85.97) 132.08,85.04 131.75,84.71 131.75,83.7 130.82,82.78 130.82,82.46 129.22,80.85 126.34,80.85 125.58,80.09 123.96,80.09 122.81,78.94 121.44,78.94 120.45,77.95 120.13,77.95 119.46,77.95 118.49,76.98 118.49,76.88 118.14,76.53 116.22,76.53 116.13,76.62 v1(115.55,76.62)
  BOTTOM w0.102: v1(115.55,76.62) 115.48,76.62 CPU1.AM7 ; RN1701.4 132.65,85.41 v1(132.08,85.97)
MCP_GPIO13: length 13.2
  BOTTOM w0.089: 119.29,73.92 119.17,74.04 118.63,74.04 118.54,73.96 118.54,73.63 118.37,73.46 117.85,73.46 CPU1.AT3
  BOTTOM w0.102: 119.29,73.92 119.49,73.72 119.81,73.72 120.64,72.89 121.24,72.89 121.53,72.6 121.53,71.53 123.31,69.75 123.87,69.75 124.03,69.58 125.81,69.58 126.21,69.98 127.21,69.98 127.39,69.8 R2020.2
MCP_GPIO14: length 26.2
  TOP w0.102: v1(116.45,78.33) 116.64,78.15 117.15,78.15 117.34,77.96 118.27,77.96 118.78,77.45 119.17,77.45 119.37,77.65 122.49,77.65 122.65,77.81 123.07,77.81 123.7,77.18 123.7,75.49 121.99,73.78 121.99,71.56 123.56,69.99 125.85,69.99 126.74,70.88 126.74,70.88 127,71.14 127.38,71.14 127.58,70.93 127.58,69.65 v2(128.04,69.19) 127.88,69.04 127.41,69.04 126.26,67.89 R2016.2
  BOTTOM w0.102: v1(116.45,78.33) 116.57,78.21 CPU1.AH4
MCP_GPIO15: length 15
  L4 w0.102: v1(115.8,81.19) 116.29,81.68 117.6,81.68 119.15,83.23 119.96,83.23 119.99,83.25 122.05,83.25 124.72,85.92 125.18,85.92 125.69,85.92 125.8,86.03 v1(126.19,86.03)
  BOTTOM w0.102: v2(125.26,86.36) 125.58,86.03 v1(126.19,86.03) 126.74,86.03 R2014.2 ; v1(115.8,81.19) 115.61,80.99 CPU1.AD6
MCP_GPIO26: length 12.3
  TOP w0.102: v1(120.84,74.62) 121.38,74.08 121.38,71.31 121.49,71.2 121.49,69.99 122.62,68.86 122.62,68.19 v2(122.82,67.99) 123.7,68.87 R2009.2
  BOTTOM w0.089: v1(120.84,74.62) 120.77,74.69 120.64,74.69 120.37,74.96 119.53,74.96 119.53,74.97 119.02,74.97 119.02,74.97 117.84,74.97 CPU1.AN3
MCP_GPIO27: length 24.6
  L4 w0.102: v1(131.86,86.62) 132.36,86.62 132.51,86.47 132.51,85.11 131.95,84.56 131.95,83.62 131.03,82.69 131.03,82.37 129.3,80.65 126.81,80.65 125.28,79.11 125.12,79.11 125.02,79.21 125.01,79.21 124.76,79.47 124.76,79.47 124.53,79.7 124.13,79.7 123.17,78.74 121.5,78.74 120.52,77.76 120.05,77.76 119.54,77.76 119.13,77.35 119.13,77.25 118.22,76.34 116.92,76.34 v1(116.46,75.88)
  BOTTOM w0.102: v1(116.46,75.88) 116.46,75.87 116.23,75.87 CPU1.AN5 ; RN2006.3 132.04,86.8 v1(131.86,86.62)
MCP_GPIO28: length 26.8
  TOP w0.102: v1(115.16,81.19) 115.16,80.98 115.44,80.7 116.58,80.7 116.96,81.08 117.92,81.08 117.93,81.08 v2(119.38,81.08) 119.61,80.85 119.61,80.09 121.01,78.69 122.23,78.69 122.25,78.71 122.26,78.71 122.37,78.82 122.38,78.82 122.4,78.85 123.44,78.85 124.44,77.84 124.61,77.84 128.05,74.4 128.05,74.21 128.63,73.64 128.63,70.24 129.73,69.14 130.07,69.14 130.37,68.83 132.65,68.83 R2017.2
  BOTTOM w0.102: v1(115.16,81.19) 114.96,80.99 CPU1.AD7
MCP_GPIO36: length 13.6
  TOP w0.102: v2(116.81,83.58) 116.25,83.58 v1(115.79,84.04) ; v1(123.19,89.35) 123.42,89.35 124.09,90.02 RN1902.4
  L4 w0.102: v1(123.19,89.35) 120.92,87.08 119.96,87.08 119.87,87.17 119.44,87.17 118.87,86.6 118.87,85.94 118.22,85.3 116.98,85.3 116.81,85.13 116.78,85.13 115.79,84.13 v1(115.79,84.04)
  BOTTOM w0.102: CPU1.V6 115.79,83.75 v1(115.79,84.04)
MCP_GPIO44: length 18.3
  TOP w0.102: v1(122.07,76.35) 121.84,76.12 121.84,74.73 121.73,74.62 121.73,74.1 121.58,73.95 121.58,71.39 121.73,71.24 121.73,71.18 123.47,69.44 125.76,69.44 126.09,69.11 126.09,68.33 125.44,67.68 R2002.2
  BOTTOM w0.089: CPU1.AK4 117.23,77.83 117.91,77.83 117.94,77.79 119.24,77.79 119.27,77.83 120.07,77.83 120.13,77.77 120.35,77.77 120.8,77.32 v2(120.8,77.31) 120.81,77.31 121.77,76.35 v1(122.07,76.35)
MCP_GPIO56: length 27.2
  TOP w0.102: R2004.2 132.54,66.97 132.54,68.44 132.36,68.63 130.29,68.63 129.99,68.93 129.64,68.93 128.34,70.23 128.34,73.58 127.81,74.11 127.81,74.3 124.51,77.6 124.34,77.6 123.36,78.58 122.41,78.58 122.26,78.43 120.93,78.43 120.71,78.65 120.4,78.65 120.24,78.49 119.33,78.49 119.02,78.8 119.02,79.81 118.71,80.12 v2(118.59,80.12) 118.13,79.66 117.09,79.66 117.02,79.73 116.25,79.73 v1(115.8,79.28)
  BOTTOM w0.102: v1(115.8,79.28) 115.61,79.09 CPU1.AG6
MCP_GPIO57: length 14.1
  BOTTOM w0.102: CPU1.AP1 119.3,74.5 119.67,74.14 120.6,74.14 121.8,72.94 121.8,71.54 123.39,69.95 123.95,69.95 124.11,69.79 125.73,69.79 126.13,70.19 127.4,70.19 127.69,70.47 v2(128.98,70.47) 129.14,70.31 R2022.2
MCP_GPIO58: length 15.1
  TOP w0.102: R2001.2 121.83,66.75 v2(121.75,66.82) 121.7,66.87 121.7,67.35 121.89,67.53 121.89,68.62 118.69,71.82 118.69,73.4 118.79,73.5 118.79,77 118.21,77.59 117.7,77.59 v1(117.24,77.13)
  BOTTOM w0.102: CPU1.AL4 117.24,77.01 v1(117.24,77.13)
MCP_GPIO73: length 19.2
  BOTTOM w0.089: CPU1.AU4 116.92,72.9 117.27,72.54 117.27,72.28 117.46,72.1 117.71,72.1 117.9,71.91 117.9,71.4 117.95,71.35 117.95,70.85 117.99,70.81
  BOTTOM w0.102: RN1601.6 131.61,68.72 131.21,68.32 131.02,68.32 130.32,67.61 v2(130.18,67.61) 129.96,67.39 125.87,67.39 124.65,68.62 124.08,68.62 123.89,68.42 122.72,68.42 122.42,68.73 121.17,68.73 119.28,70.62 118.18,70.62 117.99,70.81
MCP_GPIO76: length 10.5
  BOTTOM w0.102: RN1801.8 126.42,90.78 125.5,89.86 124.79,89.86 123.77,88.84 v2(122.91,88.84) 122.58,88.84 120.51,86.77 120.51,86.25 120.09,85.83 119.59,85.83 119.59,85.84 119.21,85.84 119.12,85.74 CPU1.P1
MCP_R: length 23.6
  TOP w0.102: v1(125.65,68.82) 125.6,68.87 R2009.1 124.71,68.4 124.9,68.2 124.9,67.77 124.33,67.2 123.66,67.2 123.54,67.08 R2001.1 125.39,66.75 R2002.1 R2016.1 ; v2(134.82,69.03) 134.52,69.03 v1(134.26,68.78) 133.84,68.35 R2013.1 133.35,67.6 R2017.1 133,67.25 133.23,67.02 R2004.1
  L4 w0.102: v1(125.65,68.82) 127.06,67.41 128.52,67.41 129.02,67.91 133.4,67.91 v1(134.26,68.78)
  BOTTOM w0.102: v1(125.65,68.82) 126.06,68.41 126.99,68.41 R2020.1 127.9,68.82 128.25,69.17 R2022.1
MCP_TESTLOW1: length 6
  BOTTOM w0.089: CPU1.C35 97.76,92.67 97.68,92.73 97.59,92.92 97.56,93.08 97.58,93.17 97.58,93.19 97.58,93.19 97.64,93.33 97.64,93.43 97.57,93.6 97.29,93.88 97.29,94.05 97.29,94.05
  BOTTOM w0.102: RN1803.4 96.39,97.26 96.72,96.94 v2(96.72,96.56) 96.72,96.42 97.29,95.85 97.29,94.05
MCP_TESTLOW2: length 6.6
  BOTTOM w0.089: CPU1.C34 98.25,92.67 97.92,92.77 97.87,92.81 97.82,92.85 97.76,92.97 97.75,93.01 97.75,93.15 97.82,93.29 97.82,93.47 97.68,93.8 97.48,94
  BOTTOM w0.102: RN1803.3 97.04,96.62 97.8,95.87 v2(97.8,95.59) 97.8,94.88 97.48,94.56 97.48,94
MCP_TESTLOW3: length 13.9
  TOP w0.102: v1(113.89,76.92) 114.17,76.65 114.17,76.61 114.87,75.9 114.87,73.11 114.7,72.94 114.7,71.68 115.14,71.25 v2(115.14,71.07) 115.14,70.11 116.35,68.89 116.35,68.14 117.09,67.4 117.09,66.96 117.37,66.68 RN1804.3
  BOTTOM w0.102: v1(113.89,76.92) 114.23,77.26 CPU1.AK8
MCP_TESTLOW4: length 13.3
  TOP w0.102: v1(113.84,76.29) 114.19,76.29 114.67,75.82 114.67,73.24 114.5,73.07 114.5,70.36 115.16,69.7 v2(115.16,69.55) 115.7,69.01 115.7,67.96 116.72,66.94 RN1804.4
  BOTTOM w0.102: CPU1.AL8 114.16,76.61 v1(113.84,76.29)
MCT0: length 12.8
  TOP w0.254: 23.96,49.78 23.58,49.39 RN3101.1
  TOP w0.508: XF3102.3 22.61,57.73 23.96,56.37 23.96,49.78
MCT1: length 8.3
  TOP w0.254: 22.93,49.89 RN3101.2
  TOP w0.508: XF3102.4 22.49,53.92 22.93,53.48 22.93,49.89
MCT2: length 13.4
  TOP w0.254: RN3101.3 22.43,49.33 v3(22.3,49.45)
  BOTTOM w0.508: v3(22.3,49.45) 23.88,51.03 23.88,56.67 22.82,57.73 XF3101.4
MCT3: length 9.1
  TOP w0.254: RN3101.4 21.78,49.06 v3(21.4,49.44)
  BOTTOM w0.508: XF3101.3 22.5,53.92 22.92,53.5 22.92,51.38 21.4,49.86 v3(21.4,49.44)
MDO0+: length 15.2
  TOP w0.102: RJ45.1 15.14,59.13 16.33,57.94 AFTP3107.1
  BOTTOM w0.102: XF3101.1 19.36,51.38 19.26,51.48 19.26,51.78 19.15,51.88 18.87,51.88 18.49,52.27 18.49,55.57 14.93,59.13 RJ45.1
MDO0-: length 15.3
  TOP w0.102: AFTP3102.1 16.88,58.28 16.36,58.28 15.43,59.2 15.4,59.23 RJ45.2
  BOTTOM w0.102: RJ45.2 15.15,59.9 15.15,59.26 18.74,55.67 18.74,52.37 18.98,52.14 19.15,52.14 19.26,52.24 19.26,52.54 19.36,52.65 XF3101.2
MDO1+: length 12
  TOP w0.102: RJ45.3 14.31,61.16 AFTP3101.1
  BOTTOM w0.102: RJ45.3 15.58,61.17 16.2,61.79 17.47,61.79 18.49,60.77 18.49,59.76 18.74,59.5 19.15,59.5 19.26,59.4 19.26,59.1 19.36,59 XF3101.5
MDO1-: length 11.4
  TOP w0.102: AFTP3106.1 16.68,64.23 RJ45.6
  BOTTOM w0.102: XF3101.6 19.36,60.27 19.26,60.16 19.26,59.86 19.15,59.76 18.85,59.76 18.74,59.86 18.74,60.88 17.58,62.04 16.84,62.04 15.4,63.48 RJ45.6
MDO2+: length 16.5
  TOP w0.102: AFTP3103.1 18.04,55.21 ; 18.04,55.21 18.04,52.89 19.05,51.88 19.76,51.88 20.27,51.38 XF3102.6 ; 18.04,55.21 18.04,61.5 16.49,63.05 15.34,63.05 15.17,62.88 15.17,62.42 RJ45.4
MDO2-: length 16.6
  TOP w0.102: 18.29,57.08 18.29,61.61 16.6,63.3 14.39,63.3 RJ45.5 ; 18.29,57.08 AFTP3104.1 ; 18.29,57.08 18.29,53 19.15,52.14 19.76,52.14 20.27,52.65 XF3102.5
MDO3+: length 12.6
  TOP w0.102: RJ45.7 15.05,65.25 15.15,65.15 16,65.15 16.27,65.42 17.6,65.42 ; 17.6,65.42 18.07,65.42 19.17,64.32 19.17,62.47 18.81,62.1 18.81,59.9 19.07,59.63 19.31,59.63 19.95,59 XF3102.2 ; 17.6,65.42 AFTP3105.1
MDO3-: length 12.5
  TOP w0.102: XF3102.1 19.93,60.27 19.54,59.89 19.18,59.89 19.06,60 19.06,62 19.43,62.36 19.43,63.68 ; AFTP3108.1 19.43,63.68 ; 19.43,63.68 19.43,64.43 18.18,65.68 16.17,65.68 15.9,65.41 15.25,65.41 15.08,65.58 15.08,65.95 RJ45.8
ME_UNLOCK: length 93.4
  TOP w0.102: KBC24.23 176.73,32.5 176.29,32.93 175.78,32.93 v1(175.36,32.51) ; R1909.1 111.3,64.72 113.19,62.84 113.19,62.42 114.39,61.22 115.17,61.22 v2(115.44,60.95) 116.11,60.29 116.11,57.35 v1(115.9,57.14)
  L4 w0.102: v1(115.9,57.14) 116.24,57.48 119.6,57.48 120.63,56.46 120.95,56.46 121.21,56.71 121.56,56.71 121.89,56.38 126.7,56.38 128.42,54.67 128.88,54.67 129.42,54.13 129.42,53.39 129.96,52.86 131.26,51.55 131.26,47.24 133.47,45.03 133.47,43.71 134.81,42.38 139.65,42.38 139.75,42.27 140.34,41.69 141.61,41.69 144.12,39.18 144.47,39.18 145.76,37.9 146.61,37.9 147.22,37.29 147.77,37.29 149.03,36.04 149.03,33.47 151.95,30.54 154.44,30.54 v1(155.1,31.2)
  BOTTOM w0.102: v1(155.1,31.2) 155.1,31.29 158,34.2 159.33,34.2 159.78,33.74 164.61,33.74 165.94,35.07 171.19,35.07 172.54,33.72 174.05,33.72 175.26,32.51 v1(175.36,32.51)
MIC2_VREFO: length 16.5
  TOP w0.203: HDA27.29 31.26,11.34 31.01,11.59 v1(30.68,11.59)
  TOP w0.254: RN2901.2 34.9,18.41 v1(35.1,18.61) 35.28,18.61 35.55,18.34 RN2901.1
  BOTTOM w0.254: v1(35.1,18.61) 35.1,18.2 35.58,17.72 v2(35.58,17.7) 35.6,17.7 37.18,16.12 37.18,14.61 36.44,13.87 33.17,13.87 30.89,11.59 v1(30.68,11.59)
MIC_CAP: length 4.5
  TOP w0.203: v2(33.81,16.3) 33.91,16.3 34.72,15.49 34.72,15.47 35.43,14.76 HDA27.19
  TOP w0.254: v2(33.81,16.3) 33.53,16.58 C2713.1
MIC_GND: length 3.3
  TOP w0.305: v2(34.3,80.51) 34.3,80.51 33.98,80.83 R5201.1 33.98,82.48 34.45,82.95 LCD1.26
MODEL_ID_DET: length 9.3
  TOP w0.102: KBC24.94 161.36,24.5 161.1,24.24 161.1,23.85 C2403.2 R2407.1 158.88,22.52 158.88,21.88 R2445.2 159.41,20.46 v2(159.66,20.2) 160.53,19.33 R2405.2 R2446.2
MPWROK: length 40.4
  L3 w0.127: v1(116.44,82.14) 116.64,81.94 117.2,81.94 117.24,81.89 118.17,81.89 118.36,81.71 119.94,81.71 120.77,82.54 123.01,82.54 123.75,81.81 125.39,81.81 125.73,81.46 125.73,79.22 124.73,78.22 119.94,78.22 118.55,76.82 118.55,64.08 118.68,63.95 v1(118.68,61.13)
  BOTTOM w0.102: v1(116.44,82.14) 116.26,81.96 CPU1.AB5
  BOTTOM w0.127: R1707.2 119.74,61.76 120.01,62.03 120.01,62.42 v2(119.84,62.59) 119.46,62.59 118.68,61.81 v1(118.68,61.13)
MUTE_CTRL: length 19.2
  TOP w0.102: R2917.2 41.74,16.81 C2901.1 42.91,17.67 R2918.2 43.36,18.15 v2(43.36,20.42) 43.26,20.52 42.67,20.52 42.38,20.23 40,20.23 38.4,18.63 v1(38.37,18.63)
  BOTTOM w0.102: U2901.2 32.62,17.48 32.99,17.85 32.99,18.81 33.26,19.08 37.91,19.08 v1(38.37,18.63)
N12P_JTAG_TCK: length 6.6
  TOP w0.102: RN7602.4 154.61,106.82 v2(154.91,106.52) 156,106.52 157.38,107.9 157.72,107.9 158.12,107.5 v1(158.39,107.5)
  BOTTOM w0.102: v1(158.39,107.5) 158.75,107.86 GPU1.AE5
N12P_JTAG_TDI: length 1.3
  TOP w0.102: v1(158.33,109.2) 158.33,109.2 158.34,109.21 158.34,109.62 TP7605.1
  BOTTOM w0.102: GPU1.AE6 158.74,108.79 158.33,109.2 v1(158.33,109.2)
N12P_JTAG_TDO: length 1.2
  TOP w0.102: TP7601.1 157.55,109.14 v1(157.55,109.19)
  BOTTOM w0.102: v1(157.55,109.19) 157.55,109.19 GPU1.AF6
N12P_JTAG_TMS: length 1.2
  TOP w0.102: v1(159.17,109.19) 159.46,108.9 TP7602.1
  BOTTOM w0.102: v1(159.17,109.19) 159.17,109.18 159.55,108.8 GPU1.AD6
N12P_JTAG_TRST: length 5.7
  TOP w0.102: RN7602.3 154.02,106.17 154.33,105.86 155.91,105.86 156.77,106.73 v2(156.77,106.74) 156.78,106.74 157.54,107.49 v1(157.55,107.49)
  BOTTOM w0.102: v1(157.55,107.49) GPU1.AG4
N12P_XTAL_OUTBUFF: length 5
  TOP w0.102: v1(176.58,112.48) 177.13,111.93 177.51,111.93 177.89,112.31 178.4,112.31 v2(178.56,112.47) 178.56,112.62 178.21,112.98 R7602.1 178.94,113.42 R7617.2
  BOTTOM w0.102: GPU1.C10 176.95,112.07 176.58,112.44 v1(176.58,112.48)
NCT7718_DXN: length 136.8
  TOP w0.254: THM26.3 114.51,109.83 C2607.2 114.23,109.88 113.22,110.89 111.22,110.89 110.72,111.4 108.66,111.4 ; v2(108.66,111.19) 108.66,111.4 ; 108.66,111.4 107.7,111.4 v1(107.61,111.3) ; v1(59.76,94.7) 59.63,94.58 59.63,82.96 63.97,78.62 63.97,66.7 44.48,47.21 44.48,39.36 46.93,36.91 C2606.2 46.91,36.88 46.91,33.45 Q2603.E
  L4 w0.254: v1(107.61,111.3) 106.98,111.3 105.7,110.02 100.39,110.02 99.57,109.21 95.7,109.21 93.26,106.77 74.86,106.77 74.32,106.24 72.84,106.24 67.96,101.36 66.38,101.36 60.77,95.75 60.22,95.75 59.68,95.2 59.68,94.79 v1(59.76,94.7)
NCT7718_DXP: length 137.9
  TOP w0.254: 110.59,111.9 110.93,111.9 111.43,111.4 113.43,111.4 114.06,110.77 C2607.1 114.75,110.48 THM26.2 ; 110.59,111.9 v2(110.59,112.16) ; 110.59,111.9 107.65,111.9 v1(107.62,111.94) ; Q2603.B 46,34.37 Q2603.C 46,36.53 C2606.1 45.62,37.5 43.97,39.14 43.97,47.42 63.46,66.91 63.46,78.41 59.13,82.75 59.13,94.62 v1(59.03,94.72)
  L4 w0.254: v1(107.62,111.94) 107.49,111.81 106.77,111.81 105.49,110.53 100.17,110.53 99.36,109.72 95.49,109.72 93.05,107.28 74.65,107.28 74.11,106.74 72.63,106.74 67.75,101.86 66.17,101.86 60.56,96.25 60.01,96.25 59.17,95.41 59.17,94.86 v1(59.03,94.72)
ODD_PWR_5V: length 10.6
  TOP w0.635: 201.51,83.35 ODD1.3 ; ODD1.3 202.25,84.09 ; ODD1.3 202.25,82.61 ; 200.01,82.35 ODD1.2 ; ODD1.2 200.75,83.09 ; ODD1.2 201.49,82.35 ; ODD1.2 200.75,81.61
  BOTTOM w0.508: 201.27,83.35 ODD1.3
  BOTTOM w0.635: ODD1.2 200.75,83.09 ; ODD1.2 201.49,82.35 ; ODD1.2 200.01,82.35 ; ODD1.2 200.75,81.61 ; 202.25,84.09 ODD1.3 202.25,82.61
  vias: v2(197.36,82.64)
OVER_CURRENT_P8#: length 126
  TOP w0.102: v1(188.83,108.66) 188.71,108.66 185.22,105.17 183.19,105.17 182.88,104.86 181.67,104.86 181.43,105.1 180.98,105.1 177.14,101.26 177.14,101.18 176.82,100.87 D7602.K ; KBC24.95 163.81,24.1 165.99,26.28 165.99,26.3 170.87,31.18 170.87,32.7 172.06,33.9 174.74,33.9 174.77,33.93 v1(175.89,33.93)
  L3 w0.102: v1(188.83,108.66) 188.83,104.87 187.03,103.08 187.03,99.56 190.68,95.91 191.38,95.91 192.63,94.66 192.63,92.22 191.35,90.94 191.35,85.32 192.14,84.53 192.14,80.35 193.14,79.34 193.14,75.71 192.59,75.16 192.55,75.16 192.05,74.65 192.05,63.47 188.58,60.01 188.58,45.25 187.74,44.41 187.74,43.7 182.55,38.51 182.55,35.37 181.53,34.36 180.54,34.36 179.78,35.12 178.13,35.12 176.81,33.8 176.02,33.8 v1(175.89,33.93)
  BOTTOM w0.102: v2(176.68,34.23) 176.27,34.23 176.17,34.13 176.1,34.13 v1(175.89,33.93)
OVERT#: length 8.2
  BOTTOM w0.127: R7652.1 182.94,102.88 R7613.2 184.91,103.6 Q7602.4 185.69,103.62 186.95,102.35 R7645.2 188.73,102.3 C7609.1 189.57,102.14 v2(189.94,102.51)
OVERT_GPU#: length 8.3
  BOTTOM w0.127: R7652.2 180.63,104.21 180.63,106.71 180.35,106.99 180.35,107.48 180.54,107.67 v2(180.54,108.04) 179.79,108.79 GPU1.A6
P2800_VGA_DXN: length 1.9
  TOP w0.254: v1(175.76,113.31) 175.77,113.31 175.77,113.36 176.36,113.95 TP7603.1
  BOTTOM w0.254: v1(175.76,113.31) 175.76,113.35 175.37,113.75 GPU1.E12
P2800_VGA_DXP: length 1.2
  TOP w0.254: TP7604.1 175.09,113.54 v1(174.9,113.35)
  BOTTOM w0.254: v1(174.9,113.35) 174.51,113.74 GPU1.F12
P_H_S#: length 3.7
  BOTTOM w0.102: R7653.1 188.94,103.28 v2(188.82,103.17) 188.44,102.79 187.4,102.79 186.81,103.37 Q7602.3
PANEL_SIZE_ID: length 105.7
  L3 w0.102: v1(62.96,81.36) 63.03,81.3 71.45,81.3 71.69,81.54 77.29,81.54 77.65,81.9 80.42,81.9 81.39,80.93 99.78,80.93 101.78,78.94 101.78,78.39 103.73,76.43 103.73,75.81 106.32,73.21 112.74,73.21 113.17,73.64 113.17,75.55 113.4,75.78 113.4,76.71 113.46,76.77 113.46,78.67 113.87,79.07 113.87,80.28 112.23,81.92 112.23,83.39 112.16,83.46 112.16,83.99 112.53,84.36 113.09,84.36 114.25,85.52 115.38,85.52 115.71,85.85 115.71,86.21 115.38,86.53 115.08,86.53 114.83,86.78 114.83,87.14 115.78,88.1 v1(115.86,88.1)
  BOTTOM w0.102: CPU1.J2 117.85,88.35 116.69,88.35 116.44,88.1 v1(115.86,88.1) ; R5210.2 R5209.1 R5208.2 38.05,86.3 38.48,86.73 39.77,86.73 v2(42.85,83.66) 43.49,83.02 61.3,83.02 v1(62.96,81.36)
PANEL_SIZE_ID_CONN: length 2.6
  TOP w0.102: v1(36.4,84.52) 36.45,84.47 LCD1.22
  BOTTOM w0.102: v2(36.75,83.94) 36.4,84.29 v1(36.4,84.52) 36.27,84.65 R5210.1
PBAT_PRES1#: length 3.8
  TOP w0.102: RN4301.8 130.39,150.3 AFTP3902.1
  TOP w0.635: 132.52,154.72 BAT1.5 132.82,154.52
PBAT_SMBCLK1: length 4.8
  TOP w0.14: AFTP3904.1 133.49,151.13 132.48,151.13 131.54,150.19 RN4301.6
  TOP w0.635: 136.52,154.72 BAT1.3 136.82,154.52
PBAT_SMBDAT1: length 3.6
  TOP w0.14: AFTP3903.1 131.52,150.91 131.04,150.43 RN4301.7
  TOP w0.635: 134.82,154.52 BAT1.4 134.52,154.72
PCB_VER_AD: length 6.8
  TOP w0.102: R2404.2 163.12,19.08 163.12,18.57 163.33,18.37 v2(163.54,18.37) 164.01,18.83 C2402.2 R2406.1 164.97,19.83 164.97,20.84 164.64,21.18 164.21,21.18 164.09,21.3 KBC24.98
PCH_DPB_AUXN: length 137.2
  TOP w0.127: v1(24.16,77.57) 24.09,77.51 23.52,77.51 23.39,77.63 23.39,78.44 23.14,78.69 22.76,78.69 C5528.1
  L4 w0.114: v1(120.26,102.26) 120.06,102.46 120.06,103.17 120.64,103.75 120.64,105.22 120,105.86 116.13,105.86 112.31,102.05 109.89,102.05 108.97,101.14 101.43,101.14 101.13,100.84 99.53,100.84 99.17,100.47 97.59,100.47 97.21,100.09 95.65,100.09 94.83,100.91 93.3,100.91 89.42,104.79 76.47,104.79 75.1,103.42 71.78,103.42 68.36,99.99 67.12,99.99 60.63,93.51 51.49,93.51 44.99,87.01 43.41,87.01 39.82,83.43 30.45,83.43 30,83.89 26.79,83.89 26.02,83.12 26.02,80.88 25.4,80.25 25.4,77.71 25.06,77.37 24.35,77.37 v1(24.16,77.57)
  BOTTOM w0.127: 119.35,97.91 119.35,98.32 120.31,99.28 121.45,99.28 122.2,100.03 122.2,101.4 121.55,102.05 120.47,102.05 v1(120.26,102.26) ; 119.35,97.91 119.35,96.08 118.27,95 117.47,95 116.57,94.1 116.12,94.1 116,93.98 116,93.41 116.12,93.29 CPU1.C5 ; 119.35,97.91 v2(119.48,97.91)
PCH_DPB_AUXP: length 137.1
  TOP w0.127: v1(24.16,76.76) 24.16,76.94 23.83,77.27 23.42,77.27 23.15,77.53 23.15,78.34 23.04,78.45 22.74,78.45 C5527.1
  L4 w0.114: v1(119.59,102.28) 119.83,102.52 119.83,103.27 120.41,103.85 120.41,105.13 119.9,105.64 116.22,105.64 112.41,101.82 109.98,101.82 109.07,100.91 101.52,100.91 101.23,100.61 99.63,100.61 99.26,100.25 97.69,100.25 97.31,99.86 95.55,99.86 94.74,100.68 93.21,100.68 89.32,104.56 76.56,104.56 75.19,103.19 71.88,103.19 68.45,99.76 67.21,99.76 60.73,93.28 51.59,93.28 45.09,86.78 43.5,86.78 39.92,83.2 30.36,83.2 29.9,83.66 26.89,83.66 26.25,83.02 26.25,80.78 25.63,80.16 25.63,77.62 25.16,77.14 24.27,77.14 24.16,77.03 v1(24.16,76.76)
  BOTTOM w0.127: 119.11,96.77 119.11,96.18 118.17,95.24 117.37,95.24 116.47,94.34 116.02,94.34 115.76,94.08 CPU1.B5 ; 119.11,96.77 v2(118.97,96.77) ; 119.11,96.77 119.11,98.42 120.21,99.53 121.35,99.53 121.96,100.13 121.96,101.3 121.45,101.81 120.37,101.81 120.37,101.82 120.05,101.82 v1(119.59,102.28)
PCH_DPB_N0: length 81.1
  TOP w0.127: C5526.1 22.75,80.38 24.86,80.38 25.24,80.75 25.52,80.75 ; 25.52,80.75 26.45,80.75 26.67,80.97 27.41,80.97 v1(27.6,81.16) ; 25.52,80.75 v2(25.52,80.92)
  L4 w0.114: v1(27.6,81.16) 27.79,80.97 28.21,80.97 28.59,81.35 29.84,81.35 30.25,80.95 52.55,80.95 67.99,96.38 72.05,96.38 74.06,98.39 81.29,98.39 82.5,99.61 85.04,99.61 v1(85.21,99.79)
  BOTTOM w0.089: CPU1.C54 85.71,92.67 85.36,92.78 85.27,92.86 85.2,93.02 85.2,93.12 85.28,93.29 85.29,93.33 85.29,93.47 85.1,93.93 85.1,94.29 85.4,94.59 85.44,94.59 85.45,94.61
  BOTTOM w0.127: v1(85.21,99.79) 85.4,99.6 85.87,99.6 86.43,99.05 86.43,97.05 86.05,96.67 86.05,95.21 85.45,94.61
PCH_DPB_N1: length 83.5
  TOP w0.127: v1(27.5,82.41) 27.32,82.41 27.07,82.66 27.07,83.06 26.76,83.36 25.36,83.36 25.28,83.45 23.92,83.45 ; 23.92,83.45 v2(23.92,83.61) ; 23.92,83.45 23.31,83.45 C5525.1
  L4 w0.114: v1(27.5,82.41) 27.18,82.41 27.12,82.46 27.12,82.78 27.24,82.89 29.47,82.89 30.89,81.47 52.32,81.47 68.05,97.19 71.98,97.19 74.42,99.64 76.98,99.64 77.28,99.93 78.98,99.93 80.47,101.41 85.09,101.41 85.22,101.28 v1(85.22,101.06)
  BOTTOM w0.127: v1(85.22,101.06) 85.22,101.31 85.13,101.39 84.46,101.39 83.81,100.74 83.81,95.29 83.58,95.07 83.58,92.76 CPU1.B58
PCH_DPB_P0: length 80.7
  TOP w0.127: v1(27.6,80.35) 27.66,80.41 27.66,80.54 27.47,80.73 26.77,80.73 26.55,80.51 25.34,80.51 24.96,80.14 22.72,80.14 C5529.1
  L4 w0.114: v1(27.6,80.35) 27.6,80.6 27.73,80.74 28.31,80.74 28.69,81.12 29.75,81.12 30.15,80.72 52.65,80.72 68.08,96.16 72.15,96.16 74.15,98.16 81.38,98.16 82.6,99.38 85.04,99.38 85.2,99.22 v1(85.2,99.06)
  BOTTOM w0.089: CPU1.C55 85.4,92.51 85.12,92.76 85.03,92.98 85.03,93.16 85.1,93.33 85.1,93.43 84.91,93.9 84.91,94.37 85.27,94.73 85.27,94.76 85.28,94.78
  BOTTOM w0.127: 85.28,94.78 85.81,95.31 85.81,96.78 86.18,97.15 86.18,98.95 85.77,99.36 85.34,99.36 85.2,99.22 v1(85.2,99.06)
PCH_DPB_P1: length 83.6
  TOP w0.127: 25.68,83.12 25.26,83.12 25.18,83.21 23.33,83.21 C5530.1 ; 25.68,83.12 v2(25.68,82.97) ; 25.68,83.12 26.66,83.12 26.83,82.96 26.83,82.55 v1(26.69,82.41)
  L4 w0.114: v1(85.16,101.85) 84.96,101.64 80.37,101.64 78.89,100.16 77.18,100.16 76.89,99.86 74.33,99.86 71.89,97.42 67.95,97.42 52.23,81.69 30.99,81.69 29.56,83.12 27.14,83.12 26.9,82.87 26.9,82.61 v1(26.69,82.41)
  BOTTOM w0.127: v1(85.16,101.85) 84.95,101.64 84.36,101.64 83.56,100.84 83.56,95.39 83.34,95.17 83.34,93.06 83.25,92.81 83.24,92.76 83.24,92.69 83.28,92.56 CPU1.C58
PCH_DPC_AUXN_U: length 2.6
  TOP w0.127: U5502.27 19.9,79.2 20.07,79.03 20.28,79.03 20.54,78.77 21.31,78.77 C5528.2
PCH_DPC_AUXP_U: length 2.7
  TOP w0.127: C5527.2 21.17,78.53 20.63,78.53 ; 20.63,78.53 v2(20.63,78.37) ; 20.63,78.53 20.44,78.53 20.18,78.79 20.02,78.79 19.93,78.7 U5502.26
PCH_DPC_N0_U: length 2.6
  TOP w0.127: 20.51,80.57 20,80.57 19.87,80.7 U5502.30 ; 20.51,80.57 v2(20.51,80.73) ; 20.51,80.57 20.93,80.57 21.01,80.5 21.36,80.5 C5526.2
PCH_DPC_N1_U: length 4.4
  TOP w0.127: U5502.32 19.94,81.7 20.06,81.57 20.44,81.57 20.72,81.86 20.72,82.67 21.19,83.14 ; 21.19,83.14 v2(21.08,83.25) ; 21.19,83.14 21.36,83.3 21.7,83.3 C5525.2
PCH_DPC_P0_U: length 2.5
  TOP w0.127: U5502.29 19.91,80.2 20.04,80.33 20.83,80.33 20.91,80.26 21.14,80.26 C5529.2
PCH_DPC_P1_U: length 4.3
  TOP w0.127: C5530.2 21.97,83.06 21.46,83.06 20.97,82.57 20.97,82.01 ; U5502.31 19.93,81.2 20.06,81.33 20.54,81.33 20.97,81.76 20.97,82.01 ; 20.97,82.01 v2(21.11,82.01)
PCH_DPWROK: length 16.7
  BOTTOM w0.089: 116.66,69.78 116.59,69.85 116.59,69.94 116.48,70.05 116.48,70.41 115.98,70.9 115.98,72.14 CPU1.AV5
  BOTTOM w0.127: R1718.1 124.87,62.47 R1704.1 124.25,62.47 123.34,63.37 121.12,63.37 120.65,63.84 120.65,64.14 119.16,65.64 v2(119.16,66.49) 119.16,67.97 117.84,69.29 117.15,69.29 116.66,69.78
PCH_INTVRMEN: length 13.1
  BOTTOM w0.089: 117.54,66.67 116.77,67.43 116.77,68.07 115.99,68.85 115.67,68.85 114.48,70.04 114.48,72.14 CPU1.AV7
  BOTTOM w0.102: 117.54,66.67 v2(117.69,66.52) 117.7,66.5 117.7,64.43 118.73,63.4 R1913.2 118.73,62.32 118.36,61.95 R1903.2
PCH_JTAG_TCK: length 6.6
  BOTTOM w0.089: 77.21,79.71 79.86,79.71 79.96,79.62 79.96,79.62 80,79.59 80.19,79.51 80.24,79.5 80.3,79.5 80.34,79.51 80.43,79.55 80.72,79.74 CPU1.AE62
  BOTTOM w0.114: 77.21,79.71 76.81,79.32 v2(75.59,79.32) 75.31,79.32 75.12,79.5 R1920.2
PCH_JTAG_TDI: length 8.1
  BOTTOM w0.089: CPU1.AD61 81.32,80.83 80.78,80.83 80.59,80.63 80.59,80.44 80.4,80.25 80,80.25 80,80.25 78.1,80.25 77.57,80.78
  BOTTOM w0.114: 77.57,80.78 v2(77.3,81.05) 77.14,81.2 76.89,81.2 76.11,81.98 R1916.1
PCH_JTAG_TDO: length 7.4
  BOTTOM w0.089: CPU1.AE61 81.23,79.42 80.65,79.42 80.51,79.39 80.39,79.34 80.33,79.33 80.21,79.33 80.18,79.33 80.09,79.35 79.95,79.39 79.57,79.54 78.6,79.54 78.58,79.52
  BOTTOM w0.114: 78.58,79.52 78.29,79.23 77.22,79.23 76.79,78.8 v2(76.76,78.8) 74.79,78.8 R1917.1
PCH_JTAG_TMS: length 7
  BOTTOM w0.089: 77.12,80.44 77.54,80.44 77.91,80.07 80.03,80.07 80.04,80.08 80.47,80.08 80.92,80.52 CPU1.AD62
  BOTTOM w0.114: R1918.1 74.83,81.32 v2(75.59,81.32) 76.24,81.32 77.12,80.44
PCH_JTAG_TRST#: length 4.9
  BOTTOM w0.089: 79.92,72.71 80.54,72.71 80.88,73.05 CPU1.AU62
  BOTTOM w0.114: TP1901.1 78.01,70.81 79.92,72.71
PCH_OPIRCOMP: length 4.9
  BOTTOM w0.102: CPU1.AW15 110.27,71.53 109.63,70.89
  BOTTOM w0.508: 109.63,70.89 109.46,70.72 109.46,70.11 v2(108.37,69.02) 108.38,69 R2003.1
PCH_PWROK: length 122.9
  TOP w0.127: v1(158.01,21) 157.67,20.65 Q2602.G ; v1(115.26,9.47) 114.8,9 Q3601.3 ; KBC24.100 164.89,21.35 165.31,20.93 v1(165.4,20.93)
  L3 w0.127: v1(115.26,9.47) 114.88,9.85 114.88,10.23 113.41,11.7 111.55,11.7 110.58,12.67 110.58,15.95 114.32,19.69 114.32,28.11 114.73,28.53 114.73,39.91 117.75,42.93 117.75,48.17 122.2,52.62 122.2,55.46 v1(121.38,56.28) ; v1(165.4,20.93) 164.89,20.93 164.66,21.16 164.29,21.16 163.47,20.33 159.5,20.33 158.83,21 v1(158.01,21)
  L4 w0.127: v1(115.26,9.47) 115.9,8.83 118.06,8.83 121.1,11.87 137.54,11.87 138.83,10.58 141.17,10.58 141.66,11.07 147.03,11.07 147.33,11.37 v1(148.81,11.37)
  BOTTOM w0.127: v1(121.38,56.28) 121.38,57.9 121.07,58.22 121.07,59.23 EC1704.1 119.73,60.56 R1706.1 ; v1(148.81,11.37) 148.79,11.39 148.79,12.67 154.21,18.08 v2(154.48,18.08) 157.01,18.08 158.01,19.09 v1(158.01,21)
PCH_SLP_S0#: length 8.3
  BOTTOM w0.089: CPU1.AF3 117.77,79.71 118.02,79.46 119.05,79.46 119.25,79.67 119.73,79.67 119.79,79.6 120.34,79.6 120.68,79.27 120.98,79.27
  BOTTOM w0.127: TP1706.1 123.43,78.25 123.05,78.25 122.7,78.6 121.94,78.6 121.27,79.27 120.98,79.27
PCH_SLP_WLAN#: length 1.4
  TOP w0.127: v1(115.55,75.97) 115.41,75.97 TP1705.1
  BOTTOM w0.102: CPU1.AM5 115.87,76.29 v1(115.55,75.97)
PCH_SMBCLK: length 327.3
  TOP w0.14: v1(29.75,69.3) 29.88,69.17 34.55,69.17 35.14,68.58 37.23,68.58 38.71,70.06 47.84,70.06 48.61,69.28 57.55,69.28 58.33,70.06 59.87,70.06 60.01,70.2 v1(60.01,70.62) ; v1(18.39,83.41) 18.39,83.3 18.01,82.93 U5502.2
  L3 w0.127: v1(119.31,39.07) 119.4,38.97 120.82,38.97 124.14,42.3 124.14,47.69 130.82,54.38 130.82,56.57 134.35,60.09 134.35,64.87 132.86,66.35 132.86,66.47 131.14,68.2 130.76,68.2 129.87,69.08 v1(129.87,69.61)
  L4 w0.127: v1(18.39,83.41) 18.34,83.35 18.34,82.78 19.84,81.27 19.84,76.9 21.98,74.76 23.31,74.76 28.94,69.13 29.59,69.13 v1(29.75,69.3) ; v1(60.01,70.62) 60.52,70.12 60.52,68.28 56.46,64.22 56.46,58.03 49.82,51.38 49.82,46.42 45.29,41.9 45.29,32.45 47.96,29.78 47.96,29.02 47.96,28.6 46.76,27.4 46.76,26.49 50.05,23.2 52.01,23.2 53.03,22.18 58.7,22.18 59.55,21.33 59.55,19.9 60.37,19.08 61.83,19.08 62.04,18.88 69.91,18.88 80.16,8.63 103.55,8.63 104.21,9.3 104.21,10.31 105.78,11.88 111.73,11.88 111.99,11.63 114.67,11.63 115.49,12.45 115.49,23.96 116.38,24.86 116.38,37.43 117.92,38.96 118.78,38.96 118.89,39.07 v1(119.31,39.07) ; v1(135.33,96.21) 135.06,95.94 135.06,94.44 135.84,93.67 135.84,92.3 136.68,91.45 136.68,89.41 135.36,88.09 135.36,84.35 134.29,83.27 134.29,69.9 132.69,68.3 130.04,68.3 129.63,68.72 129.63,69.36 v1(129.87,69.61)
  BOTTOM w0.14: RN9601.2 130.11,79.05 129.75,78.69 129.75,77.77 ; 129.75,77.77 129.75,77 129.54,76.79 RN1810.3 129.46,76.22 128.91,76.22 127.81,75.12 127.81,73.52 127.68,73.39 127.68,71.92 127.88,71.73 Q1801.4 128.42,71.21 128.57,71.06 129.18,71.06 129.63,70.62 129.63,70.36 129.96,70.02 129.96,69.7 v1(129.87,69.61) ; 129.75,77.77 v2(129.54,77.77) ; DM1.202 112.95,21.38 113.23,21.1 115.3,21.1 116.45,22.25 116.45,33.64 117.41,34.6 117.41,38.04 118.35,38.99 119.23,38.99 v1(119.31,39.07) ; v1(135.33,96.21) 135.27,96.21 EC6206.1 133.87,96.87 R6204.1
PCH_SMBDATA: length 330.3
  TOP w0.14: v1(17.73,83.51) 17.73,83.38 17.51,83.16 U5502.3 ; v1(29.73,68.5) 29.88,68.65 34.34,68.65 34.92,68.06 37.45,68.06 38.92,69.54 47.62,69.54 48.4,68.76 57.77,68.76 58.54,69.54 v1(60.01,69.54)
  L3 w0.127: v1(119.31,38.35) 119.42,38.47 121.03,38.47 124.65,42.09 124.65,47.48 131.33,54.17 131.33,56.36 134.85,59.88 134.85,65.08 133.37,66.56 133.37,66.68 131.35,68.7 130.97,68.7 130.49,69.19 v1(130.49,69.33)
  L4 w0.127: v1(29.73,68.5) 29.6,68.63 28.73,68.63 23.1,74.26 21.77,74.26 19.34,76.68 19.34,81.06 17.83,82.57 17.83,83.41 v1(17.73,83.51) ; v1(130.49,69.33) 130.33,69.33 130.13,69.14 130.13,68.93 130.25,68.81 132.48,68.81 133.78,70.11 133.78,83.48 134.86,84.56 134.86,88.3 136.18,89.62 136.18,91.24 135.33,92.09 135.33,93.46 134.55,94.23 134.55,95.84 v1(134.21,96.18) ; v1(60.01,69.54) 60.01,68.49 55.95,64.43 55.95,58.24 49.31,51.59 49.31,46.63 44.78,42.11 44.78,32.24 47.45,29.57 47.45,28.81 46.25,27.61 46.25,26.28 49.84,22.69 51.8,22.69 52.82,21.67 58.49,21.67 59.04,21.12 59.04,19.69 60.16,18.58 61.62,18.58 61.83,18.37 69.7,18.37 79.94,8.12 103.76,8.12 104.72,9.09 104.72,10.1 105.99,11.37 111.52,11.37 111.78,11.12 114.88,11.12 116,12.24 116,23.75 116.89,24.65 116.89,37.22 118.13,38.46 118.78,38.46 118.89,38.35 v1(119.31,38.35)
  BOTTOM w0.14: v1(119.31,38.35) 119.19,38.47 118.57,38.47 117.93,37.82 117.93,34.38 116.97,33.43 116.97,22.03 115.52,20.58 113.02,20.58 112.35,21.24 DM1.200 ; R6210.1 132.1,96.12 EC6205.1 134.15,96.12 v1(134.21,96.18) ; RN9601.1 130.61,79.88 130.83,79.66 130.83,79.03 130.27,78.47 130.27,76.64 130.19,76.56 RN1810.4 130.19,76.02 129.86,75.68 129.11,75.68 128.34,74.91 128.34,73.97 128.66,73.64 130.13,73.64 130.3,73.47 Q1801.1 130.67,73.03 131.04,72.66 131.04,71.7 131.01,71.67 131.01,71.29 130.77,71.05 130.35,71.05 130.15,70.85 130.15,70.58 130.49,70.24 130.49,69.97 ; v2(130.68,69.97) 130.49,69.97 ; 130.49,69.97 v1(130.49,69.33)
PCH_SPI_CLK: length 4.9
  BOTTOM w0.089: CPU1.AA3 117.92,81.71 119.72,81.71 120.44,82.43 120.66,82.43
  BOTTOM w0.14: R1806.2 121.84,82.43 121.04,82.43 v2(121.04,82.43) 121.04,82.43 120.66,82.43
PCH_SPI_CS0#: length 13
  TOP w0.14: v1(121.99,84.23) 122.1,84.34 v2(122.1,85.02) 122.1,85.62 122.43,85.95 122.43,86.45 122.37,86.5 122.37,87.04 122.62,87.28 R1807.2
  L4 w0.127: v1(115.14,83.09) 115.58,82.65 118.05,82.65 119.29,83.89 119.5,83.89 119.75,84.13 120.35,84.13 120.73,83.75 121.51,83.75 v1(121.99,84.23)
  BOTTOM w0.14: v1(115.14,83.09) 114.96,82.91 CPU1.Y7
PCH_SPI_DQ2: length 12
  TOP w0.14: R1811.2 124.75,84.94 124.36,85.34 123.31,85.34 123.14,85.16 RN1802.3 123.14,84.56 121.61,83.02 119.57,83.02 118.6,82.06 v2(118.44,82.06) 118.01,82.06 117.81,82.25 116.98,82.25 116.62,82.61 116.26,82.61 v1(115.79,83.09)
  BOTTOM w0.14: CPU1.Y6 115.61,82.91 v1(115.79,83.09)
PCH_SPI_DQ3: length 11
  TOP w0.14: R1812.2 124.03,83.19 124.03,83.89 124.28,84.14 124.28,84.51 124.05,84.74 RN1802.4 123.79,84.29 121.65,82.14 v2(121.65,80.89) 121.65,80.01 v1(121.61,79.97)
  BOTTOM w0.14: CPU1.AF1 119.01,79.87 119.95,79.87 120.01,79.8 120.43,79.8 120.5,79.73 121.37,79.73 v1(121.61,79.97)
PCH_SPI_SI: length 6.4
  BOTTOM w0.089: 120.01,82.7 119.58,82.7 119.16,82.28 118.67,82.28 118.38,82 CPU1.AA2
  BOTTOM w0.14: R1808.2 123.74,83.71 123.41,83.71 v2(122.91,83.2) 122.55,82.84 120.93,82.84 120.79,82.7 120.01,82.7
PCH_SPI_SO: length 9.7
  BOTTOM w0.089: CPU1.AA4 117.45,81.53 119.97,81.53 120.36,81.93
  BOTTOM w0.14: R1809.2 124.84,82.62 124.6,82.87 v2(124.33,82.87) 123.76,82.87 123.36,82.47 123.36,81.99 123.17,81.81 121.54,81.81 121.27,82.08 120.89,82.08 120.83,82.14 120.57,82.14 120.36,81.93
PCH_THERMTRIP: length 9.4
  BOTTOM w0.089: CPU1.D60 81.95,92.18 81.77,92.18 81.29,92.65 80.6,92.65 80.53,92.72 80.1,92.72 79.87,92.96
  BOTTOM w0.102: 79.87,92.96 79.83,92.99 79.83,94.55 79.06,95.32 R2018.2 77.11,94.8 77.18,94.73 v2(77.18,94.41) 77.02,94.25 R2027.1
PCH_VCCDSW_R: length 2.1
  TOP w0.254: R2110.2 107.11,74.55 v2(106.73,74.16) 106.27,74.62 C2114.1
PCH_WAKE#: length 22.8
  L4 w0.102: v1(131.09,83.94) 130.34,83.94 129.18,82.78 127.55,82.78 126.88,82.11 124.99,82.11 123.9,81.02 122.8,81.02 122.08,80.3 122.08,79.69 121.94,79.54 121.23,79.54 120.21,78.52 118.46,78.52 117.87,77.93 116.2,77.93 v1(115.81,78.32)
  BOTTOM w0.102: v1(131.09,83.94) 131.6,83.43 R1705.1 132.99,83.43 133.23,83.67 R1703.2 133.69,83.59 133.69,82.86 v2(133.57,82.74) ; CPU1.AJ5 116.26,77.87 115.81,78.32 v1(115.81,78.32)
PCI_PLTRST#: length 19.3
  TOP w0.127: v2(115.47,79.74) 115.15,79.42 v1(115.15,79.28)
  L4 w0.127: v1(115.15,79.28) 115.61,79.74 116.99,79.74 117.06,79.68 118.09,79.68 118.35,79.94 118.35,80.07 120.03,81.74 120.17,81.74 120.55,82.12 122.52,82.12 122.83,82.43 123.6,83.2 124.41,83.2 124.41,83.2 125.04,83.2 125.47,83.63 125.47,84.11 125.88,84.52 126.54,84.52 128.89,86.88 v1(128.89,86.97)
  BOTTOM w0.127: v1(115.15,79.28) 114.96,79.09 CPU1.AG7 ; R1713.2 129.11,87.2 v1(128.89,86.97)
PCI_PME#: length 1.1
  TOP w0.102: TP1501.1 117.29,80.18 v1(117.24,80.12)
  BOTTOM w0.102: v1(117.24,80.12) 116.94,80.42 CPU1.AD4
PCIE_CLK_XDP_N: length 5.5
  BOTTOM w0.102: TP9651.1 98.37,97.25 98.2,97.43 97.98,97.43 97.8,97.25 97.8,96.8 98.36,96.23 98.36,93.38 CPU1.B35
PCIE_CLK_XDP_P: length 5.4
  BOTTOM w0.102: CPU1.A35 98.16,93.83 98.16,96.15 97.59,96.71 97.59,97.33 97.9,97.63 98.26,97.63 98.37,97.74 TP9652.1
PCIE_PRX_LANTX_N4: length 93.2
  TOP w0.127: v2(39.84,68.42) v1(39.28,68.42)
  L4 w0.114: v1(111.03,90.76) 110.68,90.42 110.41,90.42 110.06,90.77 110.06,91.75 108.76,93.05 107.56,93.05 106.53,94.08 106.53,94.27 103.67,97.13 94.3,97.13 94.08,97.36 91.21,97.36 88.65,94.8 86.43,94.8 85.93,94.3 82.41,94.3 79.92,91.81 79.92,91.32 79.38,90.77 76.86,90.77 74.42,88.33 71.71,88.33 66.58,83.2 62.29,83.2 49.35,70.26 45.28,70.26 41.74,66.72 39.72,66.72 38.94,67.5 38.94,68.07 v1(39.28,68.42)
  BOTTOM w0.127: v1(39.28,68.42) 38.95,68.09 38.95,67.75 39.17,67.53 39.17,67.28 C3016.2 ; v1(111.03,90.76) 111.34,90.45 CPU1.F13
PCIE_PRX_LANTX_P4: length 92.8
  L4 w0.114: v1(111.02,90.1) 110.94,90.19 110.32,90.19 109.83,90.68 109.83,91.07 109.83,91.65 108.66,92.82 107.47,92.82 106.3,93.98 106.3,94.18 103.58,96.91 94.2,96.91 93.98,97.13 91.3,97.13 88.75,94.57 86.53,94.57 86.02,94.07 82.5,94.07 80.15,91.72 80.15,91.22 79.47,90.54 76.96,90.54 74.51,88.1 71.8,88.1 66.67,82.97 62.38,82.97 49.45,70.03 45.38,70.03 41.83,66.49 39.81,66.49 39.62,66.49 38.71,67.4 38.71,68.36 v1(38.65,68.42)
  BOTTOM w0.127: C3014.2 38.93,67.27 38.93,67.43 38.71,67.65 38.71,67.86 ; 38.71,67.86 v2(38.58,67.86) ; 38.71,67.86 38.71,68.36 v1(38.65,68.42) ; v1(111.02,90.1) 111.33,89.8 CPU1.G13
PCIE_PRX_WLANTX_N3: length 152.1
  TOP w0.127: v1(189.74,36.17) v2(189.74,36.87)
  L4 w0.114: v1(113,89.44) 112.84,89.6 112.56,89.6 112.24,89.92 112.24,92.76 113.33,93.86 117.12,93.86 119.78,96.52 122.34,96.52 124.34,98.52 127.66,98.52 129.56,100.42 137.75,100.42 139.58,98.6 139.58,94.51 139.44,94.37 139.44,93.67 140.53,92.58 140.53,87.42 139.42,86.31 139.42,75.91 140.53,74.81 140.53,60.18 140.99,59.72 140.99,57.58 141.42,57.15 142.28,56.29 142.28,53.88 149.06,47.1 163.32,47.1 164.95,45.47 184.61,45.47 188.47,41.61 188.47,36.45 188.97,35.95 189.53,35.95 v1(189.74,36.17)
  BOTTOM w0.127: CPU1.G11 112.84,89.44 v1(113,89.44) ; v1(189.74,36.17) 189.54,35.97 189.3,35.97 188.95,35.62 188.95,34.38 189.35,33.98 189.86,33.98 190.31,33.53 191.46,33.53 191.74,33.26 191.74,32.23 191.26,31.75 191.26,30.76 190.67,30.18 190.4,30.18 190.08,30.5 WLAN1.23
PCIE_PRX_WLANTX_P3: length 152.1
  TOP w0.127: v2(190.19,35.72) 189.78,35.31 v1(189.74,35.31)
  L4 w0.114: v1(113.02,90.1) 112.75,89.83 112.65,89.83 112.46,90.01 112.46,92.67 113.43,93.63 117.22,93.63 119.88,96.29 122.43,96.29 124.43,98.29 127.75,98.29 129.66,100.19 137.66,100.19 139.35,98.5 139.35,94.61 139.21,94.47 139.21,93.57 140.3,92.48 140.3,87.51 139.19,86.41 139.19,75.82 140.3,74.71 140.3,60.09 140.76,59.62 140.76,57.48 141.2,57.05 142.05,56.19 142.05,53.79 148.96,46.88 163.22,46.88 164.86,45.24 184.51,45.24 188.24,41.52 188.24,36.36 188.87,35.72 189.63,35.72 189.74,35.62 v1(189.74,35.31)
  BOTTOM w0.127: v1(189.74,35.31) 189.74,35.62 189.64,35.73 189.4,35.73 189.2,35.52 189.2,34.48 189.45,34.23 189.96,34.23 190.41,33.78 191.56,33.78 191.98,33.36 191.98,32.13 191.5,31.65 191.5,30.66 190.77,29.94 190.36,29.94 190.12,29.7 WLAN1.25 ; CPU1.F11 112.48,90.24 112.74,89.98 112.91,89.98 v1(113.02,90.1)
PCIE_PTX_LANRX_N4: length 4.3
  BOTTOM w0.127: CPU1.B29 101.67,93.26 101.98,93.57 101.98,93.87 101.57,94.27 101.57,95.65 ; 101.57,95.65 101.57,96.12 101.22,96.47 C1603.2 ; 101.57,95.65 v2(101.7,95.65)
PCIE_PTX_LANRX_N4_C: length 90.1
  L4 w0.114: v1(36.46,61.42) 36.13,61.09 35.96,61.09 34.86,62.19 34.86,67.3 36.4,68.83 36.71,68.83 38.27,70.39 42.7,70.39 43.9,71.59 49.58,71.59 61.7,83.72 64.28,83.72 66.56,86 68,86 70.85,88.85 74.18,88.85 76.64,91.3 76.64,92.45 77.49,93.31 80.47,93.31 81.97,94.82 85.71,94.82 86.23,95.33 88.42,95.33 90.96,97.88 94.29,97.88 94.51,97.66 100.22,97.66 100.51,97.95 100.62,97.95 101,98.33 v1(101.25,98.33)
  BOTTOM w0.127: v1(101.25,98.33) 101.25,98.26 101.22,98.23 C1603.1 ; 37.06,61.47 v2(37.06,61.6) ; 37.06,61.47 37.78,61.47 37.83,61.42 LOM30.14 ; 37.06,61.47 36.51,61.47 v1(36.46,61.42)
PCIE_PTX_LANRX_P4: length 4
  BOTTOM w0.127: CPU1.A29 101.67,93.83 101.33,94.17 101.33,96.02 101.04,96.31 100.46,96.31 100.33,96.45 C1604.2
PCIE_PTX_LANRX_P4_C: length 90
  L4 w0.114: v1(100.33,98.37) 100.33,98.09 100.13,97.88 94.61,97.88 94.39,98.11 90.86,98.11 88.32,95.56 86.13,95.56 85.62,95.05 81.88,95.05 80.37,93.54 77.4,93.54 76.41,92.55 76.41,91.4 74.09,89.08 70.76,89.08 67.9,86.22 66.47,86.22 64.19,83.95 61.61,83.95 49.48,71.82 43.81,71.82 42.61,70.62 38.17,70.62 36.61,69.06 36.3,69.06 34.63,67.39 34.63,62.09 35.87,60.86 36.31,60.86 v1(36.44,60.73)
  BOTTOM w0.127: v1(36.44,60.73) 36.93,61.23 37.68,61.23 37.88,61.02 LOM30.13 ; C1604.1 v1(100.33,98.37)
PCIE_PTX_WLANRX_N3: length 8
  BOTTOM w0.089: CPU1.C29 101.67,92.6 101.34,92.93 101.34,93.33 101.36,93.35 101.36,93.37
  BOTTOM w0.127: 101.36,93.37 101.36,93.69 100.2,94.85 100.2,95.89 ; C1601.2 99.89,99.17 99.89,98.7 99.7,98.52 99.7,96.6 100.2,96.1 100.2,95.89 ; 100.2,95.89 v2(100.32,95.89)
PCIE_PTX_WLANRX_N3_C: length 177
  TOP w0.127: v2(191.78,27.61) v1(192.33,27.61)
  L4 w0.114: v1(192.33,27.61) 192.33,27.37 192.55,27.16 193.92,27.16 194.33,27.56 194.33,41.42 192.56,43.19 192.56,43.85 186.82,49.58 185.89,49.58 184.97,48.66 182.48,48.66 182.03,48.2 170.21,48.2 168.85,49.57 165.98,49.57 165.78,49.37 149.7,49.37 144.75,54.32 144.75,56.68 143.44,57.99 143.44,60.13 142.55,61.02 142.55,93.42 141.88,94.09 141.88,98.31 141.6,98.59 141.6,99.43 140.26,100.77 139.95,101.09 139.95,103.22 137.51,105.66 124.03,105.66 122.66,107.02 105.66,107.02 105.11,107.57 101.63,107.57 100.55,106.49 100.55,102.13 v1(100.76,101.92)
  BOTTOM w0.127: v1(192.33,27.61) 192.49,27.45 192.49,27.32 192.33,27.17 191.66,27.17 191.51,27.02 190.76,27.02 190.47,27.3 WLAN1.31 ; v1(100.76,101.92) 100.76,101.72 99.77,100.73 99.77,100.54 C1601.1
