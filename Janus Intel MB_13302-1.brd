# Allegro board Janus Intel MB_13302-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_DQS_RN3: length 43.4
  BOTTOM w0.14: 189.09,129.35 v2(189,129.44) ; 189.09,129.35 187.53,127.78 187.53,127.38 187.89,127.03 187.89,126.83 187.7,126.64 187.5,126.64 187.14,127 186.74,127 186.41,126.66 186.41,126.27 186.77,125.91 186.77,125.71 186.58,125.52 186.38,125.52 186.02,125.88 185.62,125.88 185.29,125.55 185.29,125.15 185.65,124.79 185.65,124.59 185.46,124.4 185.26,124.4 184.9,124.76 184.51,124.76 184.13,124.38 182.21,124.38 181.01,123.19 180.45,123.19 179.25,121.99 GPU1.A22 ; 189.09,129.35 189.87,130.12 189.87,140.12 188.48,141.51 188.48,141.94 189.18,142.64 189.18,142.83 188.98,143.03 188.79,143.03 188.09,142.33 187.69,142.33 187.13,142.89 187.13,143.62 186.97,143.78 186.74,143.78 186.57,143.62 186.57,143.33 186.29,143.05 185.81,143.05 185.16,143.7 184.45,143.7 184.25,143.5 183.57,143.5 183.2,143.87 183.2,144.15 183.2,144.35 183.59,144.75 183.59,144.93 183.8,145.14 184.08,145.14 184.43,144.79 VRAM2.B7
FBA_DQS_RN4: length 41.9
  TOP w0.14: v2(167.1,125.29) 167.43,124.96 v1(167.43,124.84)
  L3 w0.127: v1(167.43,124.84) 167.14,124.84 167.05,124.93 167.05,126.46 167.48,126.89 167.48,128.91 167.22,129.17 166.75,129.17 166.49,128.91 166.49,127.65 166.37,127.52 166.09,127.52 165.96,127.65 165.96,130.05 164.96,131.05 164.96,131.23 165.16,131.43 165.34,131.43 166.85,129.92 167.22,129.92 167.55,130.25 167.55,130.62 165.61,132.55 163.46,132.55 160.44,135.57 159.71,136.31 156.8,136.31 155.91,137.19 154.66,137.19 153.69,138.16 153.69,141.45 153.31,141.83 153.31,142.53 154.24,143.45 154.45,143.45 154.85,143.84 v1(154.97,143.84)
  BOTTOM w0.14: GPU1.P25 167.74,124.49 167.43,124.8 v1(167.43,124.84) ; v1(154.97,143.84) 154.92,143.84 154.52,144.25 154.52,144.57 154.72,144.76 154.86,144.76 154.88,144.79 VRAM3.G3
FBA_DQS_RN5: length 40.2
  TOP w0.14: v1(155.23,142.21) 154.99,142.21 154.92,142.15 154.91,142.15 154.85,142.09 154.85,141.67 154.93,141.59 VRAM4.G3 ; v2(163.62,121.94) 164.08,122.39 v1(164.08,122.47)
  L4 w0.127: v1(155.23,142.21) 155.16,142.14 154.99,142.14 154.46,141.61 154.43,141.61 154.39,141.57 154.16,141.57 154.07,141.48 154.07,140.95 154.16,140.86 154.16,139.27 154.29,139.15 154.29,138.74 154.07,138.52 153.86,138.52 153.79,138.45 153.79,137.91 153.91,137.78 154.86,137.78 155.11,137.52 155.11,136.98 154.92,136.79 154.07,136.79 153.98,136.7 153.98,136.43 154.15,136.26 154.71,136.26 154.92,136.04 154.92,135.53 154.66,135.27 154.27,135.27 154.18,135.18 154.18,134.86 154.6,134.44 154.6,134.12 154.18,133.7 154.18,130.06 154.44,129.8 154.44,129.11 155.28,128.28 157.06,128.28 157.22,128.44 157.83,128.44 158.09,128.18 158.09,127.51 158.17,127.43 158.5,127.43 158.63,127.56 158.63,128.62 158.89,128.88 159.36,128.88 159.62,128.62 159.62,127.41 159.71,127.31 159.98,127.31 160.15,127.48 160.15,128.34 160.42,128.62 161.14,128.62 161.42,128.33 161.42,127.53 161.19,127.31 161.19,126.8 161.76,126.23 162.18,126.23 162.85,125.57 162.85,124.64 163.23,124.26 163.23,123.87 163,123.63 163,123.43 163.11,123.32 163.52,123.32 163.91,122.93 163.91,122.65 v1(164.08,122.47)
  BOTTOM w0.14: v1(164.08,122.47) 164.08,122.46 163.73,122.11 GPU1.W22
FBA_DQS_RN6: length 40
  TOP w0.14: v1(157.04,127.6) 157.58,127.6 157.58,127.6 v2(157.6,127.6) ; VRAM4.B7 151.21,144.62 151.21,144.24 150.88,143.91 149.43,143.91 149.01,144.32 148.59,144.32 148.28,144.02 148.28,143.37 148.16,143.25 147.95,143.25 v1(147.76,143.44)
  L3 w0.127: v1(147.76,143.44) 147.44,143.13 147.25,143.13 146.25,142.13 146.25,133.36 146.56,133.04 148.63,133.04 148.72,132.95 148.72,132.49 148.64,132.42 147.41,132.42 147.2,132.21 147.2,131.73 147.7,131.23 148.36,131.23 148.45,131.14 148.45,130.45 151.69,127.22 154.49,127.22 154.75,127.47 155.35,127.47 155.44,127.38 155.44,127.15 155.68,126.91 156.64,126.91 156.87,127.15 156.87,127.44 v1(157.04,127.6)
  BOTTOM w0.14: v1(157.04,127.6) 157.04,127.49 157.14,127.39 159.36,127.39 160.89,125.86 161.02,125.86 GPU1.AB27
FBA_DQS_RN7: length 41.3
  BOTTOM w0.14: v2(155.55,134.29) 155.55,134.15 ; 155.55,134.15 160.28,134.15 165.86,128.57 165.86,127.32 165.55,127.01 165.55,126.02 165.92,125.66 166.24,125.66 166.33,125.75 166.33,125.97 GPU1.T27 ; 155.55,134.15 155.06,134.15 154.92,134.29 154.92,135.36 154.65,135.63 154.14,135.63 153.87,135.36 153.87,134.29 153.74,134.15 153.46,134.15 153.32,134.29 153.32,135.7 153.07,135.94 152.49,135.94 152.15,135.61 151.92,135.61 149.65,137.89 149.28,137.89 148.99,137.59 148.79,137.59 148.59,137.79 148.59,137.99 148.79,138.19 148.79,138.55 148.36,138.98 148.36,139.17 148.69,139.5 148.69,141.42 149.14,141.87 150.02,141.87 151.09,142.93 152.74,142.93 152.96,142.72 152.96,142.45 152.85,142.35 151.72,142.35 151.49,142.12 151.49,141.48 151.36,141.36 151.14,141.36 151.04,141.46 VRAM3.B7
FBA_EDC0: length 39.8
  TOP w0.14: v2(175.44,119.4) 175.13,119.09 174.92,119.09 v1(174.91,119.1) ; v1(181.72,144.03) 181.5,144.25 181.5,144.75 VRAM1.F3
  L3 w0.127: v1(174.91,119.1) 175.13,119.31 176,119.31 177.02,120.33 177.32,120.33 182.45,125.46 182.45,134.87 182.19,135.12 181.42,135.12 181.29,135.25 181.29,135.56 181.42,135.69 182.36,135.69 182.62,135.95 182.62,136.42 182.36,136.68 181.73,136.68 181.61,136.81 181.61,137.09 181.73,137.21 183.49,137.21 183.78,137.5 183.78,137.91 183.49,138.2 181.99,138.2 181.86,138.33 181.86,138.61 181.99,138.74 182.17,138.74 182.46,139.03 182.46,139.44 182.17,139.73 181.99,139.73 181.86,139.85 181.86,140.56 181.6,140.82 181.17,140.82 181.05,140.95 181.05,141.23 181.17,141.36 181.64,141.36 182.3,142.01 182.3,142.77 181.78,143.28 181.78,143.47 181.51,143.74 181.51,143.82 v1(181.72,144.03)
  BOTTOM w0.14: v1(174.91,119.1) 175.33,119.51 GPU1.E19
FBA_EDC1: length 47.5
  TOP w0.14: v2(177.62,116.6) 177.62,116.07 v1(177.36,115.81) ; VRAM1.C7 184.38,142.03 184.38,143.03 v1(184.48,143.13)
  L4 w0.127: v1(177.36,115.81) 177.46,115.7 177.63,115.7 178.19,116.27 179.32,116.27 179.5,116.09 183.25,116.09 183.93,116.76 184.85,116.76 185.58,117.49 186.87,117.49 190.44,121.06 190.44,129.91 190.84,130.3 190.84,130.64 190.74,130.74 190.54,130.74 190.31,130.98 190.31,131.49 190.56,131.74 190.71,131.74 190.84,131.86 190.84,138.67 190.65,138.86 190.44,138.86 190.33,138.75 189.96,138.75 189.63,139.08 189.63,139.45 189.75,139.57 189.75,139.75 189.65,139.85 189.55,139.95 189.37,139.95 189.25,139.84 188.88,139.84 188.55,140.17 188.55,140.54 188.67,140.66 188.67,140.82 186.66,142.83 186.66,143.17 186.52,143.31 185.71,143.31 185.53,143.13 185.53,142.96 185.29,142.71 185.27,142.71 184.9,142.71 v1(184.48,143.13)
  BOTTOM w0.14: GPU1.C15 176.95,116.22 v1(177.36,115.81)
FBA_EDC2: length 38.7
  TOP w0.14: v2(180.54,118.41) 180.82,118.14 v1(181.31,118.14)
  L4 w0.127: v1(181.54,142.37) 181.34,142.17 181.34,140.01 181.95,139.4 181.95,139.11 181.8,138.96 181.8,138.78 182.03,138.55 182.32,138.55 183.14,137.73 183.14,137.36 182.76,136.98 182.76,136.73 182.76,136.73 184.97,134.52 184.97,124.79 184.74,124.57 184.44,124.57 184.06,124.95 183.83,124.95 183.63,124.75 183.63,124.57 184.33,123.88 184.33,123.47 184.03,123.18 183.62,123.18 182.93,123.87 182.75,123.87 182.55,123.67 182.55,123.49 182.81,123.23 182.81,122.86 182.13,122.18 181.82,122.18 181.71,122.07 181.71,121.71 181.78,121.64 182.08,121.64 182.33,121.39 182.33,120.89 181.83,120.4 181.83,119.54 182.02,119.35 182.02,118.82 181.34,118.14 v1(181.31,118.14)
  BOTTOM w0.14: v1(181.31,118.14) 180.89,118.14 179.35,116.59 178.45,116.59 178.02,117.03 GPU1.B16 ; v1(181.54,142.37) 181.39,142.21 181.39,141.74 VRAM2.F3
FBA_EDC3: length 43.5
  BOTTOM w0.14: GPU1.B22 177.75,121.75 177.89,121.61 178.68,121.61 178.82,121.75 179.35,121.75 180.55,122.95 181.11,122.95 182.31,124.14 183.87,124.14 ; v2(183.87,124.01) 183.87,124.14 ; 183.87,124.14 184.23,124.14 184.61,124.52 184.8,124.52 185.16,124.16 185.56,124.16 185.89,124.49 185.89,124.89 185.53,125.25 185.53,125.45 185.72,125.64 185.92,125.64 186.28,125.28 186.68,125.28 187.01,125.61 187.01,126.01 186.65,126.37 186.65,126.56 186.84,126.75 187.04,126.75 187.4,126.4 187.8,126.4 188.13,126.73 188.13,127.13 187.77,127.48 187.77,127.68 190.11,130.02 190.11,140.22 188.73,141.61 188.73,141.84 189.42,142.54 189.42,142.93 189.08,143.27 188.69,143.27 187.99,142.58 187.79,142.58 187.37,142.99 187.37,143.72 187.07,144.02 186.64,144.02 186.33,143.72 186.33,143.43 186.19,143.29 185.91,143.29 185.26,143.94 184.35,143.94 184.15,143.74 183.67,143.74 183.44,143.97 183.44,144.25 183.83,144.65 183.83,144.68 VRAM2.C7
FBA_EDC4: length 41.1
  L3 w0.127: v1(167.44,124.12) 166.83,124.74 166.83,126.55 167.25,126.98 167.25,128.82 167.13,128.95 166.85,128.95 166.72,128.82 166.72,127.55 166.46,127.29 165.99,127.29 165.73,127.55 165.73,129.96 164.73,130.96 164.73,131.33 165.06,131.66 165.43,131.66 166.94,130.15 167.12,130.15 167.32,130.34 167.32,130.52 165.52,132.32 163.36,132.32 160.28,135.41 159.61,136.08 156.7,136.08 155.82,136.96 154.56,136.96 153.46,138.06 153.46,141.36 153.09,141.74 153.09,142.62 154.28,143.81 v1(154.28,143.87)
  BOTTOM w0.14: GPU1.R25 167.19,124.49 167.44,124.24 v1(167.44,124.12) ; VRAM3.F3 154.28,144.75 v1(154.28,143.87)
FBA_EDC5: length 40.6
  TOP w0.14: v1(163.37,122.48) v2(163.37,123.13) ; VRAM4.F3 154.61,141.96 154.61,142.49 v1(154.76,142.64)
  L4 w0.127: v1(154.76,142.64) 154.76,142.23 154.37,141.84 154.33,141.84 154.29,141.8 154.07,141.8 153.84,141.58 153.84,140.86 153.94,140.77 153.94,139.18 154.06,139.05 154.06,138.83 153.98,138.75 153.76,138.75 153.56,138.55 153.56,137.81 153.82,137.55 154.76,137.55 154.88,137.43 154.88,137.08 154.83,137.02 153.98,137.02 153.75,136.8 153.75,136.33 154.06,136.03 154.61,136.03 154.69,135.95 154.69,135.62 154.57,135.49 154.18,135.49 153.95,135.27 153.95,134.77 154.37,134.35 154.37,134.21 153.95,133.8 153.95,129.96 154.21,129.7 154.21,129.02 155.18,128.05 157.16,128.05 157.31,128.21 157.74,128.21 157.86,128.08 157.86,127.42 158.08,127.2 158.59,127.2 158.85,127.46 158.85,128.52 158.98,128.65 159.26,128.65 159.39,128.52 159.39,127.31 159.61,127.09 160.08,127.09 160.38,127.39 160.38,128.25 160.52,128.39 161.04,128.39 161.19,128.24 161.19,127.63 160.96,127.4 160.96,126.7 161.66,126 162.09,126 162.62,125.48 162.62,124.54 163,124.16 163,123.96 162.77,123.73 162.77,123.33 163.01,123.09 163.42,123.09 163.67,122.85 163.67,122.72 163.42,122.48 v1(163.37,122.48)
  BOTTOM w0.14: v1(163.37,122.48) 163.49,122.48 163.73,122.72 GPU1.W23
FBA_EDC6: length 40.4
  TOP w0.14: v2(156.52,128.19) 156.4,128.06 v1(156.4,127.61) ; v1(147.67,142.72) 147.96,143 148.26,143 148.52,143.27 148.52,143.92 148.69,144.08 148.91,144.08 149.33,143.67 150.98,143.67 151.45,144.14 151.45,144.66 151.58,144.79 VRAM4.C7
  L3 w0.127: v1(156.4,127.61) 156.45,127.61 156.65,127.41 156.65,127.24 156.54,127.14 155.78,127.14 155.67,127.25 155.67,127.47 155.44,127.7 154.65,127.7 154.4,127.45 151.78,127.45 148.68,130.55 148.68,131.23 148.45,131.46 147.79,131.46 147.43,131.82 147.43,132.11 147.51,132.19 148.74,132.19 148.95,132.4 148.95,133.05 148.72,133.27 146.66,133.27 146.48,133.45 146.48,142.03 147.34,142.9 147.57,142.9 147.67,142.8 v1(147.67,142.72)
  BOTTOM w0.14: v1(156.4,127.61) 156.86,127.14 159.26,127.14 160.79,125.62 160.92,125.62 GPU1.AB26
FBA_EDC7: length 41.2
  BOTTOM w0.14: 161.15,132.94 v2(161.05,132.85) ; 161.15,132.94 165.62,128.47 165.62,127.42 165.31,127.11 165.31,125.92 165.82,125.42 166.08,125.42 GPU1.T26 ; 161.15,132.94 160.18,133.91 154.96,133.91 154.68,134.19 154.68,135.26 154.55,135.39 154.24,135.39 154.12,135.26 154.12,134.19 153.84,133.91 153.36,133.91 153.07,134.19 153.07,135.6 152.97,135.7 152.59,135.7 152.25,135.37 151.82,135.37 149.55,137.64 149.38,137.64 149.09,137.35 148.69,137.35 148.35,137.69 148.35,138.09 148.55,138.29 148.55,138.45 148.12,138.88 148.12,139.27 148.45,139.6 148.45,141.52 149.04,142.11 149.92,142.11 150.99,143.17 152.84,143.17 153.2,142.82 153.2,142.35 152.95,142.11 151.82,142.11 151.73,142.02 151.73,141.7 VRAM3.C7
FBA_PLL_AVDD: length 3.2
  TOP w0.356: C7505.1 174.19,116.53 v1(174.09,116.63)
  TOP w0.508: v1(168.16,121.58) 168.26,121.48 C7506.1
  BOTTOM w0.356: GPU1.H22 172.81,122.02 173.17,121.66 v1(173.18,121.65) ; GPU1.P22 167.94,121.96 167.94,121.79 v1(168.16,121.58) ; v1(174.09,116.63) 174.11,116.66 174.13,116.66 GPU1.F16
  vias: v1(167.33,120.01) v2(165.33,119.32)
FBA_VREF_0: length 36.9
  TOP w0.229: 177.14,138.98 177.14,140.39 VRAM1.M8
  TOP w0.356: v1(179.52,147.54) 179.66,147.41 179.66,146.67 VRAM1.H1
  TOP w0.381: 177.14,138.98 177.14,138.07 v1(176.98,137.9)
  TOP w0.508: v1(176.64,148.58) 177.32,147.9 179.17,147.9 v1(179.52,147.54)
  L4 w0.305: v1(176.64,148.58) 176.64,147.65 175.97,146.98 175.97,145.02 175.39,144.44 175.39,143.79 175.62,143.55 175.62,142.62 175.08,142.08 175.08,140.18 175.84,139.41 175.84,139.09 176.32,138.62 176.32,138.57 v1(176.98,137.9)
  BOTTOM w0.203: 177.15,147.44 177.15,146.17 176.74,145.75 VRAM2.M8
  BOTTOM w0.305: VRAM2.H1 179.3,139.35 179.3,138.94 179.04,138.68 178.63,138.68 177.85,137.9 v1(176.98,137.9)
  BOTTOM w0.508: v1(179.52,147.54) 179.52,147.81 178.28,149.06 178.28,149.65 178.74,150.11 R7807.1 ; 177.15,147.44 177.15,147.97 176.64,148.48 v1(176.64,148.58) 175.25,149.97 v2(174.75,149.97) 174.42,149.97 R7806.2 173.66,151.43 173.84,151.61 C7803.1
FBA_VREF_1: length 35.3
  TOP w0.203: 159.44,145.99 159.44,146.8 159.3,146.93 159.3,147.58 v1(159.51,147.78)
  TOP w0.305: VRAM4.H1 156.13,139.7 156.13,139.06 v1(156.11,139.04) ; 159.44,145.99 VRAM4.M8
  L3 w0.305: v1(158.48,138.76) 158.48,139.11 157.94,139.64 157.94,140.24 156.49,141.7 156.21,141.7 155.74,142.16 155.74,142.52 155.74,142.52 155.68,142.59 155.68,143.01 155.97,143.31 155.98,143.31 156.12,143.45 156.12,143.77 156.45,144.1 157.24,144.1 159.32,146.18 159.32,147.59 v1(159.51,147.78)
  L4 w0.508: v1(155.84,147.69) 155.5,148.03 155.5,149.16 155.86,149.52 158.68,149.52 159.51,148.69 v1(159.51,147.78)
  BOTTOM w0.203: VRAM3.M8 159.44,140.39 159.44,139.21 158.98,138.76
  BOTTOM w0.356: 155.84,146.97 VRAM3.H1
  BOTTOM w0.508: 155.84,146.97 v1(155.84,147.69) 155.09,148.44 v2(155.09,149.62) 155.34,149.87 155.34,150.64 R7904.1 C7902.1 154.39,150.7 R7903.2 ; v1(156.11,139.04) 156.11,138.69 156.42,138.38 157.9,138.38 158.28,138.76 v1(158.48,138.76) 158.98,138.76
FBA_ZQ0: length 5.8
  TOP w0.229: VRAM1.L8 177.54,140.55 177.93,140.15 177.93,139.83 177.86,139.76 177.86,139.19
  TOP w0.254: R7808.2 176.44,136.44 v2(176.71,136.71) 177.86,137.86 177.86,139.19
FBA_ZQ1: length 6
  BOTTOM w0.203: 177.92,147.48 177.92,146.23 177.54,145.85 VRAM2.L8
  BOTTOM w0.254: R7809.2 176.21,150.02 v2(176.76,149.47) 177.92,148.31 177.92,147.48
FBA_ZQ2: length 6.2
  TOP w0.254: R7912.2 v2(158.44,136.77) 158.44,137.08 157.66,137.86 157.66,139.21 v1(157.63,139.24)
  BOTTOM w0.229: VRAM3.L8 158.24,140.62 158.63,140.23 158.63,139.81 158.51,139.68 158.51,139.66 158.09,139.24 v1(157.63,139.24)
FBA_ZQ3: length 6.4
  TOP w0.178: VRAM4.L8 158.24,145.87 157.87,146.24 157.87,147 158.51,147.64 v1(158.74,147.64)
  BOTTOM w0.254: R7913.2 v2(160.42,149.67) 160.42,149.38 158.74,147.7 v1(158.74,147.64)
FON#: length 2.7
  BOTTOM w0.254: 34.49,95.32 v2(36.01,95.32) 36.52,95.83 R2605.2
GC6_FB_EN: length 211.3
  TOP w0.127: v1(131.16,67.46) 131.76,67.46 132.1,67.8 R2028.1
  L3 w0.127: v1(171.54,26.03) 171.12,25.61 168.19,25.61 167.22,26.58 164.09,26.58 161.95,28.72 160.43,28.72 159.44,29.72 158.73,29.72 158.46,29.99 158.13,30.33 158.13,31.45 156.23,33.35 156.23,34.17 154.64,35.76 154.64,36.79 150.81,40.62 v1(150.81,41.2) ; v1(172,18) 172.55,17.44 176.35,17.44 177.07,18.17 178.42,18.17 179.14,17.44 181.15,17.44 182.01,16.58 184.91,16.58 187.97,19.64 187.97,33.02 187.75,33.24 v1(187.75,34.05) ; v1(186.84,40.43) 187.42,40.43 189.02,42.03 v1(189.02,50.84) 189.02,60 192.36,63.34 192.36,74.49 193.46,75.58 193.46,79.47 192.45,80.48 192.45,84.66 191.67,85.45 191.67,90.81 192.95,92.09 192.95,95.2 191.92,96.23 190.82,96.23 187.35,99.69 187.35,102.15 189.15,103.95 189.15,107.33 189.7,107.88 v1(189.7,109.62) ; v1(131.16,67.46) 131.29,67.46 132.48,66.26 132.48,66.19 133.26,65.41 133.26,64.32 132.95,64 132.95,59.66 v1(132.69,59.4)
  L4 w0.127: v1(187.75,34.05) 187.71,34.09 187.71,39.73 187.02,40.43 v1(186.84,40.43) ; v1(171.54,26.03) 170.73,25.22 170.73,20.81 170.74,20.8 170.74,20.2 172,18.94 v1(172,18) ; v1(132.69,59.4) 132.76,59.4 134.75,57.4 134.75,55.76 136.79,53.73 136.79,49.92 140.66,46.04 141.95,46.04 144.62,43.38 145.11,43.38 147.22,41.26 150.74,41.26 v1(150.81,41.2) ; v1(189.02,50.84) 188.54,51.33 v1(184.99,51.33)
  BOTTOM w0.127: v1(189.7,109.62) 189.84,109.76 R7623.1 190.36,108.94 R7519.2 190.75,108.94 191.02,109.21 Q7603.2 ; v2(170.8,26.97) 170.8,26.96 R2451.1 171.54,26.03 v1(171.54,26.03) ; v1(184.99,51.33) 184.99,49.66 183.75,48.43 183.75,47.77 183.32,47.34 D8301.1
GC6_FB_EN_GPU: length 18.1
  BOTTOM w0.127: Q7603.3 191.79,110.3 191.45,110.65 R7623.2 189.62,110.65 v2(188.78,109.81) 188.21,109.24 188.21,108.7 187.07,107.56 185.47,107.56 185.2,107.29 R7647.1 184.99,107.3 R7627.1 183.29,107.3 182.96,107.64 181.45,107.64 179.9,109.18 177.34,109.18 GPU1.C6
GC6_FB_EN_KBC: length 6
  TOP w0.127: KBC24.106 167.29,22.89 167.84,23.44 167.84,25.52 v1(168.38,26.05)
  BOTTOM w0.127: R2451.2 169.03,26.03 v2(168.92,25.92) 168.51,25.92 v1(168.38,26.05)
GC6_FB_EN_MCP: length 22.4
  TOP w0.127: R2028.2 130.85,68.14 130.59,68.39 130.19,68.39 129.9,68.68 129.48,68.68 128.09,70.07 128.09,73.35 128.08,73.36 128.08,73.45 127.56,73.97 127.56,74.13 124.34,77.35 124.22,77.35 123.25,78.32 122.49,78.32 122.36,78.19 120.83,78.19 120.74,78.28 v2(120.56,78.28) 120.52,78.25 119.23,78.25 118.78,78.7 118.78,79.06 118.52,79.32 116.53,79.32 v1(116.51,79.3)
  BOTTOM w0.127: CPU1.AG5 116.51,79.05 v1(116.51,79.3)
GPIO5_GC6_PWR_EN: length 16.3
  BOTTOM w0.127: R7636.2 183.08,97.79 R8315.2 184.02,97.82 185.95,95.89 189.98,95.89 191.62,94.24 192.95,94.24 v2(193.37,94.66) 194.23,95.53 R8301.1 193.38,97.07 Q8301.G
GPIO5_GC6_PWR_EN#: length 6
  BOTTOM w0.127: R8303.1 193.88,98.97 Q8301.D 190.34,98.97 v2(189.76,98.39) 189.8,98.35 R8302.2
GPIO5_GC6_PWR_EN_GPU: length 10
  BOTTOM w0.127: GPU1.A3 178.69,106.43 179.47,106.43 179.82,106.09 179.82,103.87 181.14,102.54 181.14,102.27 181.53,101.88 181.75,101.88 182.09,101.54 182.09,100.54 R7633.2 182.29,100.33 v2(182.29,99.61) 182.24,99.56 R7636.1
GPIO5_GC6_PWR_EN_R#: length 4
  BOTTOM w0.127: Q8302.G 193.78,100.86 C8301.2 194.99,100.38 195.15,100.22 v2(195.15,99.94) 195.15,99.59 195.06,99.5 R8303.2
GPIO9_ALERT: length 18.1
  TOP w0.127: v1(174.9,110.02) 174.91,110.01 174.91,109.99 175.46,109.45 177.26,109.45 178.11,108.6 178.62,108.6 180.71,106.5 182.41,106.5 v1(182.48,106.56)
  BOTTOM w0.127: Q7602.1 187.93,104.92 R7612.1 188.11,105.91 v2(188.01,106.01) 187.68,106.01 187.3,105.64 184.1,105.64 183.82,105.92 183.12,105.92 v1(182.48,106.56) ; GPU1.F8 174.51,110.39 174.86,110.04 174.88,110.04 v1(174.9,110.02)
GPIO10_FBVREF: length 10.7
  BOTTOM w0.127: R7610.1 183.73,102.32 182.57,102.32 182.54,102.34 181.72,102.34 181.6,102.46 181.6,102.73 180.4,103.93 180.4,106.33 179.19,107.54 177.35,107.54 GPU1.C5
GPU_CLKREQ#: length 19.2
  TOP w0.127: R7305.2 155.47,98.93 Q7301.S 154.73,97.37 155.75,97.37 v2(156.44,98.06) 156.79,98.41 156.79,102.24 157.11,102.56 157.11,104.06 157.42,104.36 157.42,105.57 157.74,105.9 158.76,105.9 160.73,107.86 R7303.1 160.02,109.13 v1(159.95,109.2)
  BOTTOM w0.102: GPU1.AC6 160.35,108.8 v1(159.95,109.2)
GPU_EVENT#: length 161.7
  TOP w0.127: v1(136.27,72.08) 135.91,71.72 135.91,70.55 135.41,70.05 134.28,70.05 R2029.1
  L3 w0.127: v1(191.98,94.69) 191.98,92.17 191.03,91.23 191.03,85.18 191.82,84.4 191.82,80.08 191.73,79.99 191.73,63.61 188.26,60.14 188.26,45.43 187.42,44.59 187.42,43.83 181.91,38.32 181.91,36.04 v1(180.89,35.02) ; v1(136.27,72.08) 137.1,72.08 140.03,69.14 140.03,52.09 148.16,43.96 148.16,40.32 151.22,37.26 151.22,35.3 151.94,34.58 151.94,32.14 v1(152.97,31.11)
  BOTTOM w0.127: v1(152.97,31.11) 153.16,31.29 154.55,31.29 157.77,34.51 159.74,34.51 159.95,34.3 164.2,34.3 169.26,39.36 171.44,39.36 174.6,36.2 178.95,36.2 180.13,35.02 v1(180.89,35.02) ; Q7606.D 187.11,97.93 R7648.1 R7644.1 186.14,97.31 187.31,96.14 190.25,96.14 v2(191.31,95.08) 191.7,94.69 v1(191.98,94.69)
GPU_EVENT_GPU#: length 14.7
  BOTTOM w0.127: R7644.2 185.34,97.81 186.08,98.54 186.08,100.16 Q7606.S 184.84,101.4 R7649.1 182.94,101.4 v2(182.9,101.44) 182.23,102.11 181.62,102.11 181.37,102.37 181.37,102.64 180.11,103.9 180.11,106.24 179.26,107.09 GPU1.A4
GPU_EVENT_MCP#: length 27.1
  TOP w0.127: v1(115.79,82.14) 115.84,82.14 116.3,81.68 117.56,81.68 117.69,81.55 118.8,81.55 118.87,81.62 119.6,81.62 120.01,81.21 120.01,80.32 120.55,79.78 120.55,79.78 121.16,79.17 122.09,79.17 122.21,79.29 123.62,79.29 124.62,78.29 125.64,78.29 126.82,77.11 128.16,77.11 128.66,76.61 v2(128.66,75.89) 128.66,75.52 128.29,75.15 128.29,74.31 128.87,73.74 128.87,70.63 129.41,70.08 130.38,70.08 131.17,69.3 R2029.2
  BOTTOM w0.127: CPU1.AB6 115.61,81.96 v1(115.79,82.14)
GPU_PEX_RST#: length 50.1
  TOP w0.127: R7312.2 R7308.1 152.49,105.58 154.43,105.58 155.31,104.7 v1(155.31,104.1) ; v1(182.7,105.29) 182.57,105.42 180.89,105.42 177.35,101.88 177.31,101.88 177,101.57 174.06,101.57 173.25,100.77 167.8,100.77 v2(167.49,101.08) 167.05,101.52 166.22,101.52 165.81,101.92 v1(165.81,102)
  L3 w0.127: v1(159.94,110.01) 160.05,110.01 160.42,109.63 160.42,107.71 159.71,107 158.21,107 v1(155.31,104.1)
  BOTTOM w0.127: v1(182.7,105.29) 182.7,104.55 R7313.2 183.64,104.47 R7613.1 183.88,104.27 Q7602.5 ; GPU1.AC7 160.28,109.59 159.94,109.94 v1(159.94,110.01) ; v1(155.31,104.1) 156.76,102.66 165.15,102.66 v1(165.81,102)
GPU_PEX_RST_D#: length 2.5
  TOP w0.127: R7308.2 152.87,104.14 v2(152.91,104.11) 153.44,104.11 153.59,104.26 D7301.3
GPU_PEX_RST_HOLD: length 25.9
  TOP w0.127: v1(156.29,99.9) 156.39,99.99 v2(156.39,100.63) 156.39,103.18 D7301.1 ; v1(168.6,101.64) 169.23,101.02 173.14,101.02 174.47,102.35 174.47,104.11 R7631.2 174.37,105.02 R7630.2
  BOTTOM w0.127: v1(156.29,99.9) 156.69,100.3 167.12,100.3 168.47,101.64 v1(168.6,101.64)
GPU_PEX_RST_HOLD_GPU#: length 5.6
  TOP w0.127: R7630.1 175.53,104.75 v2(176.15,104.75) 176.74,104.75 v1(177.35,104.13)
  BOTTOM w0.127: GPU1.C4 177.35,106.69 177.35,104.41 v1(177.35,104.13)
GPU_PLL_VDD: length 0.6
  BOTTOM w0.356: v1(170.76,108.32) 170.35,108.73 GPU1.L6
  vias: v2(170.94,109.11)
H_CATERR#: length 5.3
  BOTTOM w0.089: 79.88,87.75 79.89,87.75 80.4,87.75 80.6,87.95 80.6,88.14 80.78,88.32 81.19,88.32 81.43,88.07 CPU1.K61
  BOTTOM w0.102: TP402.1 76.98,87.76 78.2,87.76 78.38,87.94 78.39,87.94 78.57,88.12 78.92,88.12 79.28,87.75 79.88,87.75
H_CPU_SVIDALRT#: length 5.7
  BOTTOM w0.14: CPU1.L62 80.5,86.87 77.47,86.87 77.37,86.78 77.19,86.78 v2(76.92,86.51) 75.98,85.57 R701.2
H_CPU_SVIDCLK: length 123.8
  TOP w0.14: v1(86.71,124) 86.9,123.81 89.27,123.81 93.65,128.18 v2(98.32,128.18) 99.15,128.18 99.74,127.58 105.44,127.58 106.07,128.21 119.71,128.21 121.83,126.1 121.83,123.75 123.25,122.33 123.25,115.82 120.91,113.48 118.9,113.48 118.25,114.13 PR4616.2
  BOTTOM w0.14: v1(86.71,124) 84.29,121.59 83.44,121.59 82.4,120.54 82.4,119.69 82.25,119.54 82.25,116.18 61.86,95.79 61.86,88.11 64.71,85.26 71.02,85.26 71.89,84.4 74.1,84.4 74.58,84.88 76.1,84.88 77.08,85.86 77.08,85.93 77.69,86.53 CPU1.N63
H_CPU_SVIDDAT: length 128
  TOP w0.14: v1(88.02,124.9) 88.14,125.01 89.08,125.01 93.24,129.17 v2(94.71,129.17) 99.56,129.17 100.15,128.57 105.03,128.57 105.66,129.2 120.12,129.2 122.82,126.51 122.82,124.16 124.24,122.74 124.24,115.41 121.32,112.49 118.31,112.49 117.38,113.42 115.59,113.42 114.7,114.32 PR4619.2
  BOTTOM w0.14: v1(88.02,124.9) 88.02,123.86 84.76,120.6 83.86,120.6 83.39,120.13 83.39,119.22 83.24,119.08 83.24,115.77 62.85,95.38 62.85,88.52 65.12,86.25 73.68,86.25 R704.2 74.19,86.77 76.12,86.77 76.63,87.28 77.17,87.28 77.18,87.28 CPU1.L63
H_CPUPWRGD: length 10.2
  BOTTOM w0.102: CPU1.C61 81.91,92.5 81.91,93.32 81.84,93.39 81.84,93.88 81.58,94.14
  BOTTOM w0.127: 81.58,94.14 79.71,96.01 78.53,96.01 77.7,96.84 77.7,97.28 R405.1 77.08,98.08 76.76,98.4 R411.2 76.76,99.54 TP403.1
H_PECI: length 287.5
  TOP w0.14: v1(189.03,33.51) 189.03,33.19 188.29,32.45 v2(187.73,32.45) 186.07,32.45 185.63,32.01 R2429.2
  L3 w0.127: v1(81.27,86.15) 80.69,86.74 77.3,86.74 76.58,86.02 73.15,86.02 70.93,88.24 67.67,88.24 67.24,87.81 67.24,86.64 59.12,78.52 59.12,72.6 58.45,71.93 v1(58.06,71.93)
  L4 w0.127: v1(189.03,33.51) 189.03,19.42 188.77,19.17 188.77,17.21 187.27,15.71 187.27,12.98 179.16,4.86 179.16,4.84 176.4,2.09 132.57,2.09 131.7,2.97 130.24,2.97 130.21,2.94 130.12,2.94 129.3,2.12 110.34,2.12 109.21,3.24 106.58,3.24 106.22,2.88 77.24,2.88 70.45,9.67 49.45,9.67 46.76,12.36 46.76,16.61 34.45,28.91 34.45,34.45 36.39,36.39 36.39,41.17 38.66,43.43 39.19,43.43 41.15,45.38 41.45,45.38 54.76,58.69 54.76,68.63 v1(58.06,71.93)
  BOTTOM w0.14: v1(81.27,86.15) 80.92,86.51 CPU1.N62
H_PROCHOT#: length 341.3
  TOP w0.14: v1(185.57,36.18) 185.62,36.13 R2440.2 C2421.1 ; 143.74,139.15 143.74,139.92 v1(143.46,140.2) ; 143.74,139.15 PR4466.2 ; 143.74,139.15 PR4465.1 ; PR4624.2 PR4602.2 122.38,120.67 v1(122.42,120.63) ; PR4426.2 113.02,129.79 v2(115.42,129.79) 120.36,129.79 121,129.15 v1(121.32,129.15)
  L3 w0.127: v1(82.92,114.81) 83.58,114.15 83.58,113.8 76.91,107.13 76.91,102.1 78.08,100.93 78.08,100.19 78.88,99.39 78.88,98.45 75.32,94.9 73.34,94.9 70.98,92.54 70.98,90.17 73.01,88.14 v1(75.26,88.14) ; v1(151.48,56.45) 151.48,54.68 151.64,54.52 151.64,54.2 162.67,43.17 v1(164.43,43.17) ; v1(121.32,129.15) 121.32,129.23 125.28,133.19 132.34,133.19 132.77,132.76 133.98,132.76 135.15,131.59 138.2,131.59 143.46,136.85 v1(143.46,140.2) 142.47,140.2 141.94,140.72 141.94,143.24 141.5,143.68 141.5,147.83 140.51,148.82 139.11,148.82 138.64,149.29 138.59,149.29 138.59,149.29 137.9,149.29 137.9,149.29 137.67,149.29 133.93,153.03 124.41,153.03 124.03,152.65 119.72,152.65 117.24,155.14 115.26,155.14 111.83,151.71 v1(110.82,151.71) 110.44,152.09 110.44,152.31 107.95,154.79 100,154.79 96.24,151.03 95.26,151.03 89.84,145.61 89.84,140.04 v1(92.72,137.16)
  L4 w0.127: v1(185.57,36.18) 184.69,37.06 184.69,37.81 180.48,42.02 177.18,42.02 176.92,42.28 176.92,42.29 176.01,43.2 172.62,43.2 171.89,42.46 170.51,42.46 169.8,43.17 v1(164.43,43.17) ; v1(122.42,120.63) 123.01,121.21 123.01,123.06 120.88,125.2 120.88,128.71 v1(121.32,129.15) ; v1(92.72,137.16) 86.98,137.16 85.09,135.27 85.09,123.63 82.75,121.3 82.75,114.98 v1(82.92,114.81)
  BOTTOM w0.14: R403.1 74.31,87.45 R401.2 74.65,88.05 75.17,88.05 v1(75.26,88.14) ; v1(151.48,56.45) 151.48,56.65 150.56,57.58 150.56,58.9 147.58,61.88 147.58,67.19 147.01,67.76 147.01,80.09 147.43,80.51 147.43,86.75 147.96,87.28 147.96,90.26 147.43,90.79 147.43,99.98 144.89,102.51 144.89,111.21 143.34,112.76 143.34,125.35 145.28,127.29 145.28,134.65 143.46,136.47 v1(143.46,140.2) ; PQ4203.3 110.33,151.21 v1(110.82,151.71)
H_PROCHOT#_EC: length 6.3
  TOP w0.14: R2440.1 187.06,35.39 Q2401.D 182.95,35.39 R2438.2 182.15,34.59 182.15,33.81 v2(182.22,33.75)
H_PROCHOT#_R: length 5.1
  BOTTOM w0.089: v2(78.06,88.3) 78.09,88.27 78.46,88.27 78.49,88.3 79.05,88.3 79.32,88.03 CPU1.K63
  BOTTOM w0.14: R403.2 75.96,87.82 76.52,88.39 77.97,88.39 v2(78.06,88.3)
H_RCIN#: length 126.8
  TOP w0.102: v1(117.25,83.13) 117.29,83.13 v2(118.67,84.51) 118.67,84.8 119.62,85.74 120.12,85.74 120.62,86.24 120.62,86.43 121.25,87.06 121.25,87.8 122.02,88.58 v1(122.02,88.9) 121.91,89.01 121.91,90.01 121.78,90.14 121.78,92.33 122.22,92.78 122.53,92.78 122.67,92.64 RN2002.8 ; v1(174.75,26.89) 174.75,26.63 173.69,25.57 173.69,23.57 173.69,23.57 173.69,23.21 173.69,23.21 KBC24.122
  L3 w0.102: v1(174.72,34.56) 174.3,34.98 172.4,34.98 170.04,37.34 165.27,37.34 163.55,39.07 163,39.07 162.74,39.32 162.74,40.46 164.99,42.7 164.99,43.6 162.01,46.57 160.05,46.57 152.2,54.43 152.2,54.75 152.05,54.9 152.05,56.68 151.66,57.06 150.2,57.06 149.68,57.58 148.56,57.58 144.2,61.94 144.2,71.69 139.51,76.38 139.51,81.69 136.8,84.41 134.72,84.41 133.08,86.05 133.08,86.39 132.91,86.56 132.91,88.19 132.17,88.92 130.83,88.92 130.35,89.4 130.35,90.62 129.64,91.33 128.37,91.33 127.02,92.68 125.66,92.68 125.56,92.78 122.23,92.78 121.93,92.48 121.93,88.99 122.02,88.91 v1(122.02,88.9)
  L4 w0.102: v1(174.75,26.89) 172.74,28.9 172.74,29.56 172.41,29.89 172.41,31.16 173.74,32.49 173.74,33.59 v1(174.72,34.56)
  BOTTOM w0.102: CPU1.V4 116.94,83.43 v1(117.25,83.13)
H_THERMTRIP#: length 232.1
  TOP w0.102: v1(151.82,19.6) 152.84,19.6 R3608.2 152.85,19.15 151.95,18.26 Q3602.E
  L3 w0.102: v1(78.42,92.39) 78.42,89.67 78.1,89.35 78.09,89.35 77.84,89.1 77.84,89.09 75.36,86.61 73.35,86.61 71.14,88.82 67.13,88.82 65.89,87.57 65.89,86.07 57.63,77.82 57.63,72.18 53.19,67.73 53.19,56.81 46.45,50.08 46.45,45.2 40.49,39.24 39.1,39.24 38.09,40.24 37.53,40.24 37.13,39.84 37.13,38.01 38.04,37.1 40.41,37.1 48.04,29.47 48.04,28.18 47.22,27.36 47.22,25.82 51.01,22.04 60.93,22.04 62.05,20.92 62.05,18.63 63.75,16.93 73.47,16.93 77.94,12.45 83.61,12.45 88.01,8.06 99.62,8.06 102.22,10.66 102.23,10.66 102.4,10.83 109.7,10.83 109.92,10.61 v1(112.21,10.61)
  L4 w0.102: v1(112.21,10.61) 114.89,10.61 116.34,12.06 119.36,12.06 120.06,12.75 120.06,12.76 120.54,13.23 136.39,13.23 137.19,14.04 142.36,14.04 142.47,14.15 152.65,14.15 153.06,14.56 153.06,14.57 153.06,14.57 153.06,18.37 v1(151.82,19.6)
  BOTTOM w0.102: R2027.2 76.26,93.4 76.79,93.93 78.22,93.93 78.42,93.73 v1(78.42,92.39) ; v1(151.82,19.6) 152.05,19.83 v2(152.63,19.83)
H_THERMTRIP_EN: length 233.6
  TOP w0.102: Q3602.B 153.87,18.26 154.12,18.01 C3604.1 155.4,18.01 R3605.1 155.42,17.99 R3606.2 155.71,17.2 156.35,17.84 v2(156.35,18.33) 156.37,18.33 v1(157.11,19.07)
  L3 w0.102: v1(77.71,99.38) 77.71,98.18 76.64,97.11 74.71,97.11 70.41,92.8 70.41,90.81 68.65,89.06 67.03,89.06 65.64,87.67 65.64,86.17 57.39,77.92 57.39,72.28 52.94,67.83 52.94,56.91 46.21,50.18 46.21,45.3 40.39,39.48 39.2,39.48 38.23,40.45 37.45,40.45 36.92,39.92 36.92,37.93 38,36.85 40.31,36.85 47.8,29.37 47.8,28.28 46.98,27.46 46.98,25.72 50.91,21.8 60.83,21.8 61.81,20.82 61.81,18.53 63.65,16.68 71.33,16.68 73.37,16.68 77.84,12.21 83.51,12.21 87.91,7.82 99.72,7.82 102.32,10.42 108.47,10.42 108.91,9.97 v1(112.6,9.97)
  L4 w0.102: v1(112.6,9.97) 114.54,9.97 116.37,11.8 119.45,11.8 120.3,12.65 120.64,12.99 136.82,12.99 137.63,13.8 142.46,13.8 142.57,13.91 152.96,13.91 153.56,14.51 153.56,16.73 155.9,19.07 v1(157.11,19.07)
  BOTTOM w0.102: v1(77.71,99.38) 77.71,98.77 R411.1
H_VCCST_PWRGD: length 13.2
  TOP w0.127: U701.4 78.7,96.95 R707.2 R9601.1 79.39,97.92 v2(80.19,98.72) v1(81.1,99.64)
  BOTTOM w0.089: 82.67,94.13 82.67,93.45 82.99,93.13 CPU1.B59
  BOTTOM w0.127: v1(81.1,99.64) 80.91,99.45 R706.2 EC701.1 R709.1 80.91,96.27 82.67,94.51 82.67,94.13
H_VR_ENABLE: length 79.1
  TOP w0.127: v1(72.77,90.51) 72.77,90.31 v2(73.65,89.43) 74.09,88.99 76.26,88.99 77.44,90.17 81.43,90.17 v1(81.9,90.64) ; v1(121.05,114.68) 120.89,114.84 PR4621.2
  L3 w0.127: v1(78.55,108.05) 78.55,106.08 78.29,105.82 78.29,102.01 78.73,101.57 v1(78.73,100.86) 79.45,100.14 79.45,98.22 74.87,93.64 74.87,93.58 72.77,91.48 v1(72.77,90.51)
  L4 w0.127: v1(121.05,114.68) 120.87,114.68 119.37,113.18 119.33,113.18 119.31,113.16 111.78,113.16 111.13,112.51 106.66,112.51 105.25,111.1 99.91,111.1 99.1,110.29 95.26,110.29 94.83,109.87 94.82,109.87 92.81,107.86 78.74,107.86 v1(78.55,108.05)
  BOTTOM w0.102: CPU1.F60 82.22,90.33 v1(81.9,90.64)
  BOTTOM w0.127: v1(78.73,100.86) 79.25,100.34 R710.1
HDA_BITCLK: length 10.1
  BOTTOM w0.089: 114.24,69.38 114.03,69.59 114.03,70.41 114.03,70.41 114.03,70.62 113.73,70.92 113.73,71.45 CPU1.AW8
  BOTTOM w0.14: 114.24,69.38 v2(114.55,69.08) 115.46,68.17 115.46,66.52 116.15,65.82 R1907.2
HDA_CODEC_BITCLK: length 124.6
  TOP w0.14: R2720.1 41.78,10.37 EC2709.1 43.17,9.79 44.01,9.79 44.32,10.1 44.32,11.92 44.18,12.06 43.7,12.06 43.56,12.2 43.56,12.51 43.7,12.65 44.18,12.65 44.32,12.79 44.32,13.11 44.18,13.25 43.7,13.25 43.56,13.39 43.56,13.71 43.7,13.85 44.18,13.85 44.32,13.99 44.32,14.55 47.83,18.06 v2(47.83,21.94) 47.83,24.8 46.68,25.95 46.68,28.79 46.72,28.83 v1(46.72,28.92)
  BOTTOM w0.14: R1907.1 116.15,60.54 118.06,58.64 118.06,57.4 119.22,56.24 119.22,52.03 EC1901.2 119.03,51.84 119.03,51.27 105.99,38.23 56.89,38.23 55.92,37.26 55.72,37.26 55.48,37.5 55.28,37.5 55.05,37.28 55.05,37.08 55.3,36.84 55.3,36.64 55.08,36.41 54.88,36.41 54.63,36.66 54.43,36.66 54.21,36.44 54.21,36.24 54.46,35.99 54.46,35.79 54.23,35.57 54.03,35.57 53.79,35.82 53.59,35.82 53.37,35.59 53.37,35.39 53.61,35.15 53.61,34.95 53.12,34.46 48.71,34.46 46.62,32.36 46.62,29.02 v1(46.72,28.92)
HDA_CODEC_RST#: length 120
  TOP w0.14: HDA27.11 39.12,12.54 39.34,12.75 39.34,14.62 R2917.1 41.31,16.26 42.11,15.46 42.63,15.46 46.08,18.91 46.08,23.99 44.85,25.21 v2(44.85,26.79) v1(44.85,28.43)
  BOTTOM w0.14: v1(44.85,28.43) 45,28.29 46.92,28.29 47.24,28.61 47.24,30.12 47.31,30.19 47.31,31.89 48.9,33.48 53.07,33.48 57.2,37.62 106.2,37.62 119.61,51.03 119.61,51.38 119.8,51.57 119.8,56.48 118.81,57.47 118.81,58.84 117,60.66 R1911.1
HDA_CODEC_SDIN0: length 3.6
  TOP w0.14: HDA27.8 39.86,11.34 40.38,11.85 v2(40.38,11.85) 41.1,12.57 R2718.2
HDA_CODEC_SDOUT: length 130
  TOP w0.14: v1(42.29,9.39) 42.37,9.46 42.67,9.46 42.93,9.2 44.25,9.2 44.91,9.86 44.91,10.15 44.91,14.3 48.42,17.81 48.42,25.04 47.27,26.19 47.27,28.55 47.3,28.58 47.3,29.16 47.27,29.19 47.27,29.74 46.88,30.13 45.05,30.13 v1(44.82,30.36) ; R1912.1 112.14,64.68 113.75,63.07 113.75,62.65 v2(113.75,62.65) 114.62,61.78 115.41,61.78 116.82,60.38 116.82,56.98 v1(117.32,56.48)
  BOTTOM w0.14: v1(42.29,9.39) 42.16,9.25 41.77,9.25 41.54,9.48 EC2708.1 R2719.1 ; v1(117.32,56.48) 117.32,56.35 117.06,56.09 117.06,54.45 116.08,53.46 116.08,50.96 105.1,39.98 57.62,39.98 57.62,39.99 55,39.99 51.22,36.21 48.96,36.21 47.99,36.21 44.85,33.07 44.85,30.38 v1(44.82,30.36)
HDA_CODEC_SYNC: length 123.2
  TOP w0.14: v1(45.5,28.87) 45.51,28.86 45.51,25.47 46.66,24.32 46.66,18.67 42.87,14.88 40.9,14.88 39.92,13.9 39.92,12.74 39.32,12.14 HDA27.10 ; R1908.1 112.92,65.76 112.92,64.73 114.07,63.58 114.47,63.58 v2(115.51,62.53) 117.44,60.6 117.44,57.41 118.2,56.66 118.2,55.7 v1(118.26,55.64)
  BOTTOM w0.14: v1(45.5,28.87) 45.81,28.87 46.02,29.07 46.02,32.59 48.47,35.04 51.99,35.04 55.24,38.29 56.13,38.29 56.65,38.82 105.75,38.82 117.24,50.31 117.24,52.98 118.26,53.99 v1(118.26,55.64)
HDA_RST#: length 11.5
  BOTTOM w0.089: 116.13,67.98 114.31,69.8 114.31,69.95 114.31,72.21 114.34,72.25 114.34,72.75 CPU1.AU8
  BOTTOM w0.14: 116.13,67.98 116.13,66.82 v2(116.36,66.59) 117,65.95 R1911.2
HDA_SDIN0: length 125.8
  TOP w0.14: v1(44.87,29.45) 44.91,29.49 45.75,29.49 46.1,29.14 46.1,25.71 47.25,24.56 v2(47.25,23.94) 47.25,18.3 43.2,14.25 43.01,14.25 42.6,13.85 R2718.1
  BOTTOM w0.089: 114.3,68.23 113.66,68.87 113.66,70.47 113.3,70.83 113.3,71.06 CPU1.AY10
  BOTTOM w0.14: v1(44.87,29.45) 44.94,29.53 45.32,29.53 45.43,29.64 45.43,32.83 48.23,35.63 48.71,35.63 51.46,35.63 55.24,39.41 55.73,39.41 55.74,39.4 105.34,39.4 116.66,50.72 116.66,53.22 117.68,54.24 117.68,55.88 117.9,56.11 117.9,56.72 117.47,57.16 117.47,58.37 115.05,60.79 115.05,66.06 114.3,66.81 114.3,68.23
HDA_SDOUT: length 8
  TOP w0.14: v1(112.15,72.74) 112.15,72.73 111.66,72.25 111.66,71.7 v2(111.07,71.11) 111.07,66.94 R1909.2 R1912.2
  BOTTOM w0.14: CPU1.AU11 112.46,73.04 112.19,72.76 112.17,72.76 v1(112.15,72.74)
HDA_SPKR: length 149.9
  TOP w0.254: v1(48.47,32.15) 47.32,32.15 46.74,31.57 44.85,31.57 44.19,30.91 44.19,28.63 v2(41.43,25.86) 40.88,25.86 40.05,25.04 RN2701.2
  L3 w0.254: v1(122.83,86.81) 122.83,86.57 123.67,85.73 123.67,83.3 124.19,82.78 124.55,82.78 125.34,82.78 126.13,81.98 126.13,81.69 126.18,81.64 126.18,79.04 124.92,77.77 121.2,77.77 120.62,77.2 120.62,75.79 119.88,75.05 119.62,75.05 119.18,74.61 119.18,73.22 119.04,73.08 119.04,72.66 119.16,72.53 119.16,64.09 119.42,63.83 119.42,57.32 120.5,56.25 120.5,51.54 117.31,48.35 117.31,43.12 v1(116.63,42.44)
  BOTTOM w0.089: 122.04,84.79 122.39,84.44 122.39,84.03 122.16,83.8 121.61,83.8 121.42,83.62 120.79,83.62 120.46,83.29 119.75,83.29 119.67,83.37 119.31,83.37 119.16,83.21 118.53,83.21 CPU1.V2
  BOTTOM w0.254: 122.04,84.79 121.49,85.34 121.49,86.48 121.94,86.94 122.12,86.94 122.76,87.57 R2006.2 122.95,86.92 v1(122.83,86.81) ; v1(48.47,32.15) 49.16,32.84 53.36,32.84 56.96,36.44 57.28,36.44 57.68,36.84 106.34,36.84 111.74,42.24 116.44,42.24 v1(116.63,42.44)
HDA_SPKR_R: length 3.5
  TOP w0.254: D2701.2 40.05,21.71 RN2701.3 39.04,23.16 v2(38.86,22.98)
HDA_SYNC: length 6.3
  TOP w0.14: v1(112.14,72.08) 112.14,71.2 112.14,71.19 v2(112.14,68.75) 112.14,67.96 112.98,67.12 R1908.2
  BOTTOM w0.14: v1(112.14,72.08) 112.14,72.07 112.45,72.39 CPU1.AV11
HDD_DEVSLP: length 2.6
  TOP w0.102: TP2001.1 119.61,86.66 119.84,86.43 v1(119.84,86.43)
  BOTTOM w0.089: CPU1.P2 118.39,85.89 118.39,86.01 118.59,86.21 119.05,86.21 119.18,86.34 119.58,86.34 119.67,86.43 v1(119.84,86.43)
HSIO_OUT:
  vias: v2(123,105.16)
HSIOPC: length 28.9
  L3 w0.102: v1(122.37,92.27) 123.39,91.25 124.18,91.25 125.07,90.37 127,90.37 127.61,89.75 127.61,87.95 126.97,87.32 125.3,87.32 125.04,87.57 122.58,87.57 121.97,86.96 v1(121.97,86.15)
  BOTTOM w0.089: CPU1.Y2 118.53,83.03 119.34,83.03
  BOTTOM w0.102: R2123.1 R2007.1 124.93,95.58 124.02,94.68 124.02,93.9 123.21,93.09 123.21,92.98 122.5,92.27 v1(122.37,92.27) ; v1(121.97,86.15) 121.97,85.47 v2(122.63,84.81) 122.9,84.54 122.9,84.05 122.31,83.46 121.52,83.46 121.5,83.43 120.86,83.43 120.53,83.1 119.41,83.1 119.34,83.03
HSIOPC_R: length 7.5
  TOP w0.102: v1(125.25,102.02) 124.89,101.67 v2(124.28,101.67) 124.01,101.67 v1(123.44,101.1)
  BOTTOM w0.102: v1(125.25,102.02) 125.25,102.22 125.01,102.45 U2101.9 ; R2123.2 124.04,97.46 122.88,98.62 122.88,99.05 123.34,99.51 123.34,101 v1(123.44,101.1)
HSYNC_5: length 9.2
  L3 w0.127: v1(22.27,86.82) 22.33,86.75 22.33,83.96 23.07,83.22 v1(23.07,81.01)
  BOTTOM w0.14: v1(23.07,81.01) 22.84,80.78 U5501.3 ; v2(21.71,86.94) 21.83,86.82 v1(22.27,86.82) 22.66,86.43 RN5502.1
HVM_CLK: length 6.6
  TOP w0.102: TP620.1 104.42,86.31 104.53,86.2 105.87,86.2 106.19,86.52 107.1,86.52 107.54,86.08 107.71,86.08 107.77,86.01 108.17,86.01 108.17,86.01 108.52,86.01 v1(108.96,85.57)
  BOTTOM w0.102: CPU1.R20 108.08,85.07 108.17,85.16 108.49,85.16 108.52,85.2 108.58,85.2 v1(108.96,85.57)
HVM_CLK#: length 3.4
  TOP w0.102: TP619.1 106.22,85.89 106.65,86.32 107.01,86.32 107.52,85.81 108.08,85.81 v1(108.32,85.57)
  BOTTOM w0.102: CPU1.P20 108.01,85.88 v1(108.32,85.57)
I2C0_SCL: length 6.6
  BOTTOM w0.089: 120.45,92.28 120.43,92.27 120.43,92.04 119.21,90.81 118.6,90.81 118.37,90.58 117.97,90.58 CPU1.F3
  BOTTOM w0.14: 120.45,92.28 121.41,93.25 122.1,93.25 122.3,93.45 RN2007.2
I2C0_SDA: length 6.5
  BOTTOM w0.089: CPU1.F2 118.29,90.24 118.68,90.62 119.29,90.62 120.57,91.9 120.8,91.9 120.82,91.92
  BOTTOM w0.14: RN2007.1 122.95,93.36 122.32,92.73 v2(121.87,92.73) 121.63,92.73 120.82,91.92
I2C1_SCL: length 22.1
  BOTTOM w0.14: CPU1.F1 119.27,90.28 119.67,90.68 119.86,90.68 120.53,91.35 121.96,91.35 v2(121.99,91.38) 122.27,91.38 123.59,92.7 123.59,92.94 124.39,93.74 124.39,94.5 125.41,95.52 126,96.11 RN2008.2 126,96.98 126.11,97.1 127.4,97.1 EC6203.1 128.18,97 RN6203.2 128.91,97.22 128.47,97.65 128.47,98.77 129.97,100.27 132.13,100.27 132.62,99.78 Q6204.1
I2C1_SCL_R: length 17.3
  TOP w0.14: TPAD1.6 133.9,95.03 134,95.13 134,95.71 133.13,96.58 AFTP6237.1 132.9,97.01 132.29,97.01 v1(131.77,97.53) 131.42,97.88 130.5,97.88 130.17,98.21 130.17,98.8 v1(130.27,98.9)
  BOTTOM w0.14: RN6203.3 128.91,98.63 129.18,98.9 v1(130.27,98.9) 130.27,99.1 130.95,99.78 Q6204.6 ; v1(131.77,97.53) 132.38,96.92 R6204.2 133.97,97.96 134.51,97.96 134.72,98.16 135.25,98.16 135.84,98.75 135.84,99.51 135.64,99.71 RN6204.4
I2C1_SDA: length 19.9
  BOTTOM w0.127: CPU1.G4 117.25,89.83 119.56,89.83 119.64,89.91
  BOTTOM w0.14: 119.64,89.91 119.88,90.16 120.07,90.16 120.74,90.83 121.83,90.83 121.83,90.83 122.46,90.83 123.42,91.79 ; Q6204.4 131.43,98.48 129.95,97 RN6203.1 129.56,96.56 129.33,96.33 128.56,96.33 128.41,96.48 127.86,96.48 EC6204.1 127.72,96.58 126.73,96.58 RN2008.1 126.65,95.86 126.52,95.72 126.35,95.72 125.93,95.3 124.91,94.29 124.91,93.53 124.11,92.72 124.11,92.48 123.42,91.79 ; 123.42,91.79 v2(123.44,91.77)
I2C1_SDA_R: length 15.7
  TOP w0.14: v1(130.71,98.42) 131.62,98.42 v1(132.51,97.53) 133.11,97.53 133.67,96.97 134.85,96.97 AFTP6240.1 135.05,96.56 134.69,96.21 134.69,95.32 134.9,95.11 TPAD1.7
  BOTTOM w0.14: RN6204.3 134.88,99.06 134.3,98.48 Q6204.3 133.5,98.23 132.8,97.53 v1(132.51,97.53) 131.98,98.06 131.57,98.06 131.2,97.69 R6210.2 ; RN6203.4 130.49,98.2 v1(130.71,98.42)
I2CA_SCL: length 8
  TOP w0.14: 182.16,109.84 182.81,110.48 184.33,110.48 184.41,110.56 RN7603.3 ; 182.16,109.84 181.76,109.44 v1(180.9,109.44) ; 182.16,109.84 v2(182.07,109.93)
  BOTTOM w0.14: v1(180.9,109.44) 180.85,109.44 180.25,110.04 178.7,110.04 178.67,110 178.16,110 GPU1.B7
I2CA_SDA: length 7.2
  TOP w0.14: 183.31,109.96 183.02,109.96 181.98,108.92 181.06,108.92 v1(180.92,108.78) ; 183.31,109.96 v2(183.31,109.84) ; 183.31,109.96 184.73,109.96 RN7603.4
  BOTTOM w0.14: GPU1.A7 178.63,109.52 180.03,109.52 180.77,108.78 v1(180.92,108.78)
I2CB_SCL: length 10.4
  TOP w0.14: RN7605.3 182.69,116.61 182.56,116.48 181.79,116.48 v2(180.43,115.12) 180.07,114.76 180.07,114.23 179.57,113.73 179.57,112.97 178.68,112.09 177.98,112.09 177.55,111.65 v1(176.55,111.65)
  BOTTOM w0.14: v1(176.55,111.65) 176.57,111.65 GPU1.C9
I2CB_SDA: length 9.6
  TOP w0.14: RN7605.4 182,115.96 v2(181.71,115.66) 180.59,114.54 180.59,114.01 180.09,113.51 180.09,112.75 178.9,111.57 178.2,111.57 177.5,110.86 v1(177.36,110.86)
  BOTTOM w0.14: GPU1.C8 176.95,110.45 v1(177.36,110.86)
I2CC_SCL: length 7.4
  TOP w0.14: v1(180.9,110.74) 181.1,110.74 182.46,112.09 ; v2(182.37,112.18) 182.46,112.09 ; 182.46,112.09 182.81,112.45 184.27,112.45 184.4,112.57 RN7604.3
  BOTTOM w0.14: GPU1.A9 178.66,111.38 178.83,111.38 179.26,110.95 180.69,110.95 v1(180.9,110.74)
I2CC_SDA: length 8.4
  TOP w0.14: 183.53,111.92 RN7604.4 ; 183.53,111.92 v2(183.53,111.8) ; 183.53,111.92 183.02,111.92 181.32,110.22 181.01,110.22 v1(180.9,110.1)
  BOTTOM w0.14: v1(180.9,110.1) 180.78,110.21 180.68,110.21 180.47,110.43 179.05,110.43 178.72,110.75 178.72,110.75 178.61,110.86 178.16,110.86 GPU1.B9
IFPAB_IOVDD: length 4.3
  TOP w0.102: RN7402.3 163.97,108.14 v1(164.16,108.32) 164.16,108.36 164.95,109.15 v2(164.95,109.2)
  BOTTOM w0.102: GPU1.Y6 GPU1.W6 163.75,108.73 v1(164.16,108.32)
IFPAB_PLLVDD: length 3.9
  TOP w0.102: RN7402.4 163.32,108.12 v2(163.32,108.12) 163.32,108.29 v1(164.13,109.11)
  BOTTOM w0.102: GPU1.V7 164.53,109.5 v1(164.13,109.11) 163.73,109.51 GPU1.W7
IFPC_IOVDD: length 3
  TOP w0.102: RN7401.3 166.01,107.38 166.57,107.95 v1(166.57,108.32) v2(166.16,108.73)
  BOTTOM w0.102: GPU1.R6 166.98,108.73 v1(166.57,108.32)
IFPC_PLLVDD: length 4.8
  TOP w0.102: RN7401.4 165.36,107.61 v2(165,107.97) 165,108.41 165.74,109.15 v1(166.6,109.15)
  BOTTOM w0.102: GPU1.T7 166.59,109.15 v1(166.6,109.15) 166.98,109.53 GPU1.R7
IFPD_IOVDD: length 3
  TOP w0.102: v2(167.88,108.7) 167.84,108.7 v1(167.46,108.32) 167.46,108.15 168.04,107.57 RN7404.3
  BOTTOM w0.102: GPU1.P6 167.46,108.34 v1(167.46,108.32)
IFPD_PLLVDD: length 8.1
  TOP w0.102: v1(167.46,109.21) 166.98,108.73 166.98,107.41 167.39,107 RN7404.4 167.39,106.47 166.78,105.87 166.78,104.61 v2(166.42,104.24)
  BOTTOM w0.102: GPU1.M7 169.3,109.72 168.88,109.72 GPU1.N7 167.78,109.53 v1(167.46,109.21)
IFPEF_IOVDD: length 8.8
  TOP w0.102: RN7403.3 171.14,105.31 170.94,105.5 170.59,105.5 170.35,105.74 170.35,106.24 170.51,106.39 v2(170.51,106.75) 170.32,106.94 170.32,109.25 170.66,109.59 171.14,109.59 171.27,109.47 172.16,109.47 v1(172.41,109.21)
  BOTTOM w0.102: GPU1.J6 171.97,108.77 v1(172.41,109.21) 172.81,108.82 GPU1.H6
IFPEF_PLLVDD: length 8.2
  TOP w0.102: RN7403.4 170.49,105.24 170,105.73 170,109.92 v2(170.28,110.2) 171.32,110.2 v1(171.58,109.94)
  BOTTOM w0.102: GPU1.J7 171.97,109.55 v1(171.58,109.94) 171.56,109.94 171.17,109.55 GPU1.K7
IMVP_PWRGD: length 190.4
  TOP w0.127: v1(120.93,117.05) 121.3,117.05 121.74,117.5 R4622.2 PR4628.2 ; v1(168.29,24.14) 168.12,23.97 168.12,23.31 167.69,22.88 KBC24.107
  L3 w0.127: v1(148.15,53.33) 148.59,53.78 148.97,53.78 149.23,53.52 149.23,53.2 150.19,52.24 150.19,48.51 154.22,44.47 154.22,43.14 158.07,39.3 158.61,39.3 161.03,36.89 161.81,36.89 162.63,36.06 163.57,36.06 165.95,33.68 v1(168.83,33.68) ; v1(79.27,101.24) 79.27,101.38 78.55,102.11 78.55,105.71 79,106.17 79,107.97 79.33,108.3 v1(79.33,108.47)
  L4 w0.127: v1(168.29,24.14) 168.29,25.16 168.82,25.69 168.82,33.25 168.83,33.26 v1(168.83,33.68) ; v1(79.33,108.47) 79.62,108.18 92.78,108.18 95.14,110.55 98.99,110.55 99.81,111.36 105.15,111.36 106.56,112.76 111.02,112.76 111.67,113.42 119.21,113.42 120.6,114.81 120.6,114.86 120.93,115.2 v1(120.93,117.05) 121.22,116.76 121.22,116.06 121.53,115.75 121.53,111.47 121.84,111.16 122.78,111.16 122.79,111.16 123.16,110.78 123.83,110.78 123.84,110.77 123.85,110.77 124.56,110.07 124.56,109.09 125.23,108.41 138.72,108.41 142.68,104.45 142.68,102.22 144.33,100.57 144.33,99.72 144.66,99.39 144.66,95.17 145.85,93.98 145.85,87.94 144.34,86.43 144.34,61.77 145.23,60.87 145.23,60.32 148.3,57.26 148.3,56.38 149.16,55.52 149.16,54.34 v1(148.15,53.33)
  BOTTOM w0.127: v2(169.65,34.59) 169.35,34.59 168.83,34.07 v1(168.83,33.68) ; v1(79.27,101.24) 79.34,101.24 79.73,100.86 79.73,100.14 80.08,99.79 R713.1
IMVP_PWRGD_R: length 9.8
  BOTTOM w0.089: CPU1.C59 82.99,92.64 82.7,92.94 82.7,93.17 82.49,93.38 82.49,93.9 82.45,93.94
  BOTTOM w0.102: 82.45,93.94 82.38,94.01 82.38,94.21
  BOTTOM w0.127: v2(78.28,99.74) 78.73,99.74 R710.2 79.65,98.81 R713.2 80.08,98.43 80.02,98.37 EC702.1 R712.1 80.02,96.56 82.38,94.21
INT_SERIRQ: length 134.6
  TOP w0.14: v1(174.34,25.53) 174.34,24.7 174.59,24.45 174.59,24.13 174.89,23.84 KBC24.125 ; v1(117.26,84.63) 117.7,85.07 118.02,85.07 118.73,85.78 118.73,86.62 119.16,87.06 119.72,87.06 120.32,87.06 120.59,87.33 120.59,88.43 121.05,88.89 121.05,89.21 121.25,89.41 121.25,89.74 121.12,89.87 121.12,92.6 121.99,93.47 v2(121.99,93.54) 122.24,93.79 RN2002.6
  L3 w0.127: v1(174.9,35.49) 174.9,35.65 173.37,37.18 170.79,37.18 170.27,37.71 167.89,37.71 165.95,39.65 165.95,45.75 166.04,45.84 166.04,47.62 163.94,49.72 159.63,49.72 154.56,54.8 154.56,55.34 152.01,57.89 150.54,57.89 150.03,58.4 148.91,58.4 144.96,62.35 144.96,71.81 141.54,75.23 141.54,85.24 139.08,87.7 135.1,87.7 134.29,88.52 133.39,88.52 132.41,89.49 131.27,89.49 130.93,89.83 130.93,90.87 129.89,91.91 128.61,91.91 127.27,93.26 125.89,93.26 125.8,93.35 121.99,93.35 121.25,92.61 121.25,91.35 120.22,90.33 120.22,89.96 120.65,89.54 120.65,88.76 118.64,86.76 118.64,86.13 117.26,84.75 v1(117.26,84.63)
  L4 w0.127: v1(174.9,35.49) 174.67,35.49 173.37,34.2 173.37,32.65 172.04,31.32 172.04,29.74 172.37,29.41 172.37,28.55 174.34,26.59 v1(174.34,25.53)
  BOTTOM w0.14: CPU1.T4 116.94,84.95 v1(117.26,84.63)
INT_TP#: length 133.5
  TOP w0.102: R6203.1 129.61,97.27 v1(130.45,96.44) 130.83,96.82 AFTP6241.1 131.54,96.82 131.77,96.59 131.77,95.19 131.9,95.06 TPAD1.4 131.9,93.57 v1(132.2,93.26) ; R2031.1 130.37,66.74 131.25,66.74 131.97,66.02 134.27,66.02 R2030.1 135.58,66.75 v1(135.71,66.62) ; v1(178.8,21.17) 178.69,21.05 R2448.1 178.69,19.39 R2453.1
  L3 w0.102: v1(135.71,66.62) 135.61,66.53 135.61,65.83 136.09,65.35 136.09,56.81 133.8,54.53 133.8,51.12 144.24,40.69 144.24,39.5 144.24,38.96 146.52,36.68 146.52,34.03 148,32.55 148,31.45 148,30.9 152.6,26.31 152.6,25.62 155.14,23.08 155.14,22.66 155.52,22.28 161.3,22.28 161.79,21.79 167.78,21.79 167.85,21.86 170.02,21.86 171.03,20.85 171.03,20.82 171.3,20.56 172.19,20.56 172.2,20.55 172.97,20.55 173.44,21.02 178.65,21.02 v1(178.8,21.17)
  L4 w0.102: v1(130.45,96.44) 130.73,96.72 132.99,96.72 133.17,96.89 135.74,96.89 136.09,96.54 136.09,94.56 136.6,94.05 136.6,93.21 137.74,92.07 137.74,90.94 138.28,90.39 138.28,88.34 137.18,87.24 137.18,74.98 137.79,74.38 137.79,69.33 135.71,67.25 v1(135.71,66.62)
  BOTTOM w0.102: R1512.1 132.09,93.15 v1(132.2,93.26)
INT_TP#_GPIO8: length 14.5
  TOP w0.102: R2031.2 128.53,66.91 R2015.2 128.52,67.4 v1(128.07,67.84)
  L4 w0.102: v1(128.07,67.84) 127.52,67.84 v1(126.52,68.84)
  BOTTOM w0.089: 119.5,73.34 119.33,73.34 119.29,73.38 118.55,73.38 CPU1.AU2
  BOTTOM w0.102: v1(126.52,68.84) 125.98,69.38 123.94,69.38 123.78,69.54 123.22,69.54 120.95,71.81 120.67,71.81 120.25,72.23 120.25,72.74 119.65,73.34 119.5,73.34
INT_TP#_GPIO46: length 24.6
  TOP w0.102: R2030.2 134.1,66.42 133.94,66.26 132.07,66.26 131.34,66.99 130.98,66.99 130.39,67.59 R2010.2 129.8,68.39 129.4,68.39 127.84,69.96 127.84,73.35 123.11,78.08 122.63,78.08 122.48,77.93 119.15,77.93 v2(119.03,77.81) 118.71,77.81 v1(117.89,78.62)
  BOTTOM w0.102: CPU1.AG3 117.59,78.92 v1(117.89,78.62)
INT_TP#_GPIO55: length 26.7
  TOP w0.102: v2(115.49,84.52) 115.49,84.65 v1(115.15,84.99)
  L4 w0.102: v1(132.09,91.84) 129.84,91.84 129.74,91.74 128.4,91.74 127.63,90.97 127.63,90.14 127.38,89.88 127.38,89.37 126.57,88.56 125.04,88.56 123.8,87.32 123.8,86.96 123.01,86.17 122.63,86.17 121.13,84.68 120.09,84.68 119.94,84.52 119.61,84.52 119.46,84.38 118.77,84.38 117.99,83.61 114.31,83.61 114.05,83.86 114.05,84.22 114.34,84.51 114.67,84.51 v1(115.15,84.99)
  BOTTOM w0.102: CPU1.U7 114.96,84.8 v1(115.15,84.99) ; v1(132.09,91.84) 132.29,91.84 R1512.2
INT_TP#_KBC: length 6.3
  TOP w0.127: R2448.2 177,21.04 175.35,21.04 v2(174.7,20.39) 174.27,20.39 173.29,21.36 KBC24.121
ISOLATE#: length 4.5
  TOP w0.102: R3014.2 38.39,65.08 R3015.1 v2(39.31,65.08) 39.73,65.08 v1(39.99,64.81)
  BOTTOM w0.102: v1(39.99,64.81) 40.19,64.62 LOM30.20
ISUM_R_C: length 32.8
  TOP w0.254: 107.74,125.58 v2(107.74,125.8) ; 107.74,125.58 98.28,125.58 97.71,126.15 95.62,126.15 v1(94.88,125.42) ; 107.74,125.58 112.84,125.58 113.12,125.3 PR4708.2 PC4707.2 PC4708.2 115.29,126.05 PC4710.1 PC4709.1 116.19,126.04 PR4705.1
  BOTTOM w0.254: PG4702.1 94.22,118.69 94.88,119.34 PR4704.2 v1(94.88,125.42)
ISUM_R_R: length 0.9
  TOP w0.254: PR4706.1 117.08,126.04 PC4709.2
JACK_PLUG: length 14.6
  BOTTOM w0.254: HPMIC1.5 13.61,12.8 16.91,9.49 R2905.1 17.59,8.21 C2902.1 R2923.1 20.11,8.6 v2(20.88,9.36) 21.49,9.36 Q2901.G
JACK_PLUG_DET: length 11.9
  BOTTOM w0.254: HPMIC1.6 10.16,13.81 13.48,13.81 v2(17.02,10.27) 17.55,10.81 R2916.1 R2914.2
