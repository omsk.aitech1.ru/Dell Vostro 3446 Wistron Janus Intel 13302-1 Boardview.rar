# Allegro board Janus Intel MB_13302-1.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
QFN10M3-G4P-UH34
  rect 0.61x0.254 smd: 1(1.346,1.125) 2(1.346,0.675) 3(1.346,0.225) 4(1.346,-0.225) 5(1.346,-0.675) 6(1.346,-1.125)
  rect 0.254x1.168 smd: 7(0.66,-1.067)
  rect 1.981x0.914 smd: 8(-0.66,-0.94)
  custom 0.483x0.483 smd: 9(-0.432,0.051)
  rect 1.143x0.813 smd: 10(-0.241,0.991)
QFN20-G1D75H32
  rect 0.203x0.914 smd: 1(0.8,1.551) 2(0.4,1.551) 3(0,1.551) 4(-0.4,1.551) 5(-0.8,1.551) 11(-0.8,-1.551) 12(-0.4,-1.551) 13(0,-1.551) 14(0.4,-1.551) 15(0.8,-1.551)
  rect 0.914x0.203 smd: 6(-1.551,0.8) 7(-1.551,0.4) 8(-1.551,0) 9(-1.551,-0.4) 10(-1.551,-0.8) 16(1.551,-0.8) 17(1.551,-0.4) 18(1.551,0) 19(1.551,0.4) 20(1.551,0.8)
  rect 1.753x1.753 smd: 21(0,0)
QFN20G3D5-G2D15H40
  rect 0.305x0.914 smd: 1(1,1.801) 5(-1,1.801) 11(-1,-1.801) 15(1,-1.801)
  rect 0.305x0.965 smd: 2(0.5,1.775) 3(0,1.775) 4(-0.5,1.775) 12(-0.5,-1.775) 13(0,-1.775) 14(0.5,-1.775)
  rect 0.914x0.305 smd: 6(-1.801,1) 10(-1.801,-1) 16(1.801,-1) 20(1.801,1)
  rect 0.965x0.305 smd: 7(-1.775,0.5) 8(-1.775,0) 9(-1.775,-0.5) 17(1.775,-0.5) 18(1.775,0) 19(1.775,0.5)
  rect 2.159x2.159 smd: 21(0,0)
QFN20G4030-G275175H40
  rect 0.305x0.914 smd: 1(1.25,1.551) 2(0.75,1.551) 3(0.25,1.551) 4(-0.25,1.551) 5(-0.75,1.551) 6(-1.25,1.551) 11(-1.25,-1.551) 12(-0.75,-1.551) 13(-0.25,-1.551) 14(0.25,-1.551) 15(0.75,-1.551) 16(1.25,-1.551)
  rect 0.914x0.305 smd: 7(-2.051,0.75) 8(-2.051,0.25) 9(-2.051,-0.25) 10(-2.051,-0.75) 17(2.051,-0.75) 18(2.051,-0.25) 19(2.051,0.25) 20(2.051,0.75)
  rect 2.743x1.753 smd: 21(0,0)
QFN32-G3D6H40
  rect 0.305x0.914 smd: 1(1.75,2.559) 8(-1.75,2.559) 17(-1.75,-2.559) 24(1.75,-2.559)
  rect 0.305x1.016 smd: 2(1.25,2.508) 3(0.75,2.508) 4(0.25,2.508) 5(-0.25,2.508) 6(-0.75,2.508) 7(-1.25,2.508) 18(-1.25,-2.508) 19(-0.75,-2.508) 20(-0.25,-2.508) 21(0.25,-2.508) 22(0.75,-2.508) 23(1.25,-2.508)
  rect 0.914x0.305 smd: 9(-2.559,1.75) 16(-2.559,-1.75) 25(2.559,-1.75) 32(2.559,1.75)
  rect 1.016x0.305 smd: 10(-2.508,1.25) 11(-2.508,0.75) 12(-2.508,0.25) 13(-2.508,-0.25) 14(-2.508,-0.75) 15(-2.508,-1.25) 26(2.508,-1.25) 27(2.508,-0.75) 28(2.508,-0.25) 29(2.508,0.25) 30(2.508,0.75) 31(2.508,1.25)
  rect 3.556x3.556 smd: 33(0,0)
QFN32J4-G2D9-U1H36
  rect 0.203x0.864 smd: 1(1.4,2.085) 2(1,2.085) 3(0.6,2.085) 4(0.2,2.085) 5(-0.2,2.085) 6(-0.6,2.085) 7(-1,2.085) 8(-1.4,2.085) 17(-1.4,-2.085) 18(-1,-2.085) 19(-0.6,-2.085) 20(-0.2,-2.085) 21(0.2,-2.085) 22(0.6,-2.085) 23(1,-2.085) 24(1.4,-2.085)
  rect 0.864x0.203 smd: 9(-2.085,1.4) 10(-2.085,1) 11(-2.085,0.6) 12(-2.085,0.2) 13(-2.085,-0.2) 14(-2.085,-0.6) 15(-2.085,-1) 16(-2.085,-1.4) 25(2.085,-1.4) 26(2.085,-1) 27(2.085,-0.6) 28(2.085,-0.2) 29(2.085,0.2) 30(2.085,0.6) 31(2.085,1) 32(2.085,1.4)
  rect 2.692x2.692 smd: 33(0,0)
QFN48J6-G465H40
  rect 0.203x0.965 smd: 1(2.2,3.025) 2(1.8,3.025) 3(1.4,3.025) 4(1,3.025) 5(0.6,3.025) 6(0.2,3.025) 7(-0.2,3.025) 8(-0.6,3.025) 9(-1,3.025) 10(-1.4,3.025) 11(-1.8,3.025) 12(-2.2,3.025) 25(-2.2,-3.025) 26(-1.8,-3.025) 27(-1.4,-3.025) 28(-1,-3.025) 29(-0.6,-3.025) 30(-0.2,-3.025) 31(0.2,-3.025) 32(0.6,-3.025) 33(1,-3.025) 34(1.4,-3.025) 35(1.8,-3.025) 36(2.2,-3.025)
  rect 0.965x0.203 smd: 13(-3.025,2.2) 14(-3.025,1.8) 15(-3.025,1.4) 16(-3.025,1) 17(-3.025,0.6) 18(-3.025,0.2) 19(-3.025,-0.2) 20(-3.025,-0.6) 21(-3.025,-1) 22(-3.025,-1.4) 23(-3.025,-1.8) 24(-3.025,-2.2) 37(3.025,-2.2) 38(3.025,-1.8) 39(3.025,-1.4) 40(3.025,-1) 41(3.025,-0.6) 42(3.025,-0.2) 43(3.025,0.2) 44(3.025,0.6) 45(3.025,1) 46(3.025,1.4) 47(3.025,1.8) 48(3.025,2.2)
  rect 4.648x4.648 smd: 49(0,0)
R402H14
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H15
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H16
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R603H22
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
R805H24
  rect 1.549x0.94 smd: 1(0,0.838) 2(0,-0.838)
R1206H28
  rect 1.854x1.27 smd: 1(0,1.397) 2(0,-1.397)
R1210H24
  rect 2.794x1.397 smd: 1(0,1.473) 2(0,-1.473)
R3720H40
  rect 4.013x1.041 smd: 1(0,0.867) 2(0,-0.867)
SC70-5-1H44
  rect 0.356x1.219 smd: 1(-0.65,-0.922) 2(0,-0.922) 3(0.65,-0.922) 4(0.65,0.921) 5(-0.65,0.921)
SC70-5H44
  rect 0.406x1.219 smd: 1(0.65,0.826) 2(0,0.826) 3(-0.65,0.826) 4(-0.65,-0.826) 5(0.65,-0.826)
SC70-6H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
SE361413H182
  rect 1.372x3.556 smd: 1(0,2.424) 2(0,-2.424)
SE361414H178
  rect 1.372x3.607 smd: 1(0,2.499) 2(0,-2.499)
SE361416H178
  rect 1.422x3.556 smd: 1(0,2.574) 2(0,-2.574)
SKT-USB8-166140-2
  round 1.346 hole 0.94: 1(3.5,10.45) 2(1,10.45) 3(-1,10.45) 4(-3.5,10.45)
  oval 1.575x2.972 hole 0.914x2.311: 5(-6.4,9.6) 6(6.4,9.6)
  oval 1.626x3.124 hole 0.914x2.413: 7(-7.85,0) 8(7.85,0)
SKT-USB13-157164
  round 1.067 hole 0.711: 1(3.5,9.41) 2(1,9.41) 3(-1,9.41) 4(-3.5,9.41) 5(-4,7.91) 6(-2,7.91) 7(0,7.91) 8(2,7.91) 9(4,7.91)
  oval 1.321x3.2 hole 0.711x2.489: 10(7.7,7.43) 11(-7.7,7.43)
  oval 1.321x2.819 hole 0.711x2.108: 12(7.7,0) 13(-7.7,0)
SMD49-6914-0403H56
  rect 1.168x0.559 smd: 1(-3.38,-0.427) 2(3.38,-0.427) 3(3.38,0.427) 4(-3.38,0.427)
SMD-ARES4H18
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SMD-ARES4H20
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SOD123FLAKH40
  rect 1.143x1.651 smd: A(0,1.622) K(0,-1.622)
SOD323AKH38
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD323AKH40
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD323AKH42
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD723AKH27
  rect 0.559x0.813 smd: A(0,0.686) K(0,-0.686)
SOD-523-4H28
  rect 0.559x0.864 smd: 1(0,0.778) 2(0,-0.778)
SOIC8-1H86
  rect 0.635x1.651 smd: 1(-1.905,-3.493) 2(-0.635,-3.493) 3(0.635,-3.493) 4(1.905,-3.493) 5(1.905,3.493) 6(0.635,3.493) 7(-0.635,3.493) 8(-1.905,3.493)
SOIC8H69
  rect 0.635x1.651 smd: 1(-1.905,-2.54) 2(-0.635,-2.54) 3(0.635,-2.54) 4(1.905,-2.54) 5(1.905,2.54) 6(0.635,2.54) 7(-0.635,2.54) 8(-1.905,2.54)
SOT23-2D4-312H44
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D4-312H48
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D8-123H52
  custom 0.254x0.254 smd: 1(0,1.118) 2(-1.016,-1.118) 3(1.016,-1.118)
SOT23CBE2D4H44
  custom 0.191x0.191 smd: B(-0.984,-0.953) C(0,0.953) E(0.984,-0.953)
SOT23DGS2D4H44
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D4H48
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT323CBE2D2H44
  custom 0.152x0.152 smd: B(-0.65,-0.902) C(0,0.902) E(0.65,-0.902)
SOT-6H58
  rect 0.584x1.016 smd: 1(-0.953,-1.346) 2(0,-1.346) 3(0.953,-1.346) 4(0.953,1.346) 5(0,1.346) 6(-0.953,1.346)
SOT-23-5H51
  rect 0.508x1.524 smd: 1(-0.95,-1.143) 2(0,-1.143) 3(0.95,-1.143) 4(0.95,1.143) 5(-0.95,1.143)
SOT-23-5H56
  rect 0.508x1.524 smd: 1(-0.95,-1.143) 2(0,-1.143) 3(0.95,-1.143) 4(0.95,1.143) 5(-0.95,1.143)
SOT-23-5H58
  rect 0.508x1.524 smd: 1(-0.95,-1.143) 2(0,-1.143) 3(0.95,-1.143) 4(0.95,1.143) 5(-0.95,1.143)
SOT-23-9H44
  custom 0.178x0.178 smd: 1(-0.95,-0.999) 2(0.95,-0.999) 3(0,0.999)
SOT-23-10H44
  rect 0.762x1.143 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT-23-13H51
  rect 0.66x1.321 smd: 1(-0.999,-0.978) 2(0.999,-0.978) 3(0,0.978)
SOT-363H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
SPR4527H308
  rect 8.992x3.404 smd: 1(-2.248,0)
SPR5630H142
  rect 5.283x2.692 smd: 1(-2.413,0)
SPR5930H154
  rect 5.588x2.692 smd: 1(-1.702,0)
STF237R117H83
  round 6.02 hole 2.972: 1(0,0)
TPAD14-OP
  round 0.356 smd: 1(0,0)
TSOIC14H48
  rect 0.356x1.524 smd: 1(-1.949,-2.819) 2(-1.3,-2.819) 3(-0.65,-2.819) 4(0,-2.819) 5(0.65,-2.819) 6(1.3,-2.819) 7(1.949,-2.819) 8(1.949,2.819) 9(1.3,2.819) 10(0.65,2.819) 11(0,2.819) 12(-0.65,2.819) 13(-1.3,2.819) 14(-1.949,2.819)
unnamed#2
  round 1.016 smd: (0,0)
XFORM12A127097H91
  rect 0.635x1.524 smd: 1(-4.445,-4.699) 2(-3.175,-4.699) 3(-1.905,-4.699) 4(1.905,-4.699) 5(3.175,-4.699) 6(4.445,-4.699) 7(4.445,4.699) 8(3.175,4.699) 9(1.905,4.699) 10(-1.905,4.699) 11(-3.175,4.699) 12(-4.445,4.699)

## Nets
3V3_AON_S0: C7315.1 C7316.1 C7324.1 C8307.1 C8308.1 GPU1.AA8 GPU1.AA9 GPU1.AB8 GPU1.G10 GPU1.G12 PG8312.2 PR8203.1 PR8258.1 Q7301.G Q7602.2 Q7606.G R7303.2 R7312.1 R7605.1 R7606.1 R7612.2 R7615.1 R7617.1 R7624.2 R7625.1 R7631.1 R7633.1 R7634.1 R7635.1 R7643.2 R7645.1 R7646.1 R7649.2 R8304.1 R8315.1 RN7601.3(B) RN7601.4(B) RN7603.1(A) RN7603.2(A) RN7604.1(A) RN7604.2(A) RN7605.1(A) RN7605.2(A) U7301.5
3V5V_CT1: C3602.1 U3601.12
3V5V_CT2: C3601.1 U3601.10
3V5V_S0_ON: R3609.2 U3601.3 U3601.5
3V_5V_EN: D3602.1 PR4506.1 PR4507.1 R3602.1 R3603.1
3V_5V_POK: PR4534.2 PU4503.7 R1728.2
3V_5V_POK#: Q1701.5 Q1701.6 R1726.1
3V_5V_POK_C: Q1701.2 R1727.2 R1728.1 R1729.1
3V_FEEDBACK: PG4535.2 PR4512.1 PR4535.1
5V_CRT_S0: C5516.1 D5501.K F5501.2 RN5501.3(B) RN5501.4(B) U5501.14
5V_CRT_S0_R: C5519.1 CRT1.9 F5501.1
5V_PWR: PC4515.1 PC4518.1 PD4503.1 PG4519.2 PG4523.2 PG4527.2 PG4532.1 PG4533.2 PG4537.2 PG4538.2 PG4540.2 PG4541.2 PG4544.2 PG4545.2 PL4501.2 PT4501.1
5V_PWR_2: PC4524.1 PU4503.13 R2915.1
5V_S0: C2605.1 C2611.1 C3603.1 C5605.1 C5606.1 C5609.1 D5501.A EC9718.1 EC9719.1 EC9720.1 EC9721.1 EC9722.1 EC9723.1 EC9724.1 F6201.1 FAN261.2 HDD1.P7 HDD1.P8 HDD1.P9 PC4604.1 PR8223.1 PU4601.12 Q6201.E R2702.1 R2703.2 R2704.1 R5230.1 R5603.1 R5801.1 R5807.1 R6205.1 R6216.1 U3601.13 U3601.14 U5601.2 U5601.3 U8301.4
5V_S5: C3501.1 C3502.1 C3504.1 C3505.1 C3510.1 EC9732.1 EC9733.1 EC9734.1 PC4815.1 PC4901.1 PG4519.1 PG4523.1 PG4527.1 PG4533.1 PG4537.1 PG4538.1 PG4540.1 PG4541.1 PG4544.1 PG4545.1 PR4203.1 PU4806.7 PU4901.12 Q6103.E Q6104.E R1208.1 U2101.1 U3501.2 U3501.3 U3502.2 U3503.5 U3504.5 U3505.5 U3601.1 U3601.2 U3601.4
15V_PWR: PC4533.1 PD4501.K PD4502.2 PG4530.2
15V_S5: PG4530.1 PR4471.2 PR8310.2
+3V_1D5V_AVDD: C2715.1 HDA27.40 R2705.2 R2710.2
+3V_AVDD: C2701.1 C2716.1 C2717.1 C2719.1 HDA27.1 HDA27.9 HDA27.36 R2701.2 R2722.1 R2918.1
+5V_AVDD: C2710.1 C2711.1 HDA27.26 R2703.1
+5V_KB_BL: AFTP6248.1 C6202.1 F6201.2 KBLIT1.1 R6205.2
+5V_MINI_DEBUG: R5801.2 R5805.2 WLAN1.51
+5V_PVDD: C2706.1 C2707.1 C2708.1 C2709.1 HDA27.41 HDA27.46 R2702.2 R2704.2
+V1.05A_AOSCSUS: CPU1.AB8 TP2109.1
+V1.05A_SUS_PCH: CPU1.AD8 CPU1.AD10 TP2106.1
+V1.05A_USB2SUS: CPU1.AH13 TP2108.1
+V1.05A_VCCUSB3SUS: CPU1.J13 TP2107.1
+V1.05DX_MODPHY_PCH: C1101.1 C1102.1 CPU1.K9 CPU1.L10 CPU1.M9 R1101.2
+V1.05S_AIDLE: C2105.1 CPU1.N8 CPU1.P9 R2105.2
+V1.05S_APLLOPI: C1109.1 C1110.1 C1124.1 CPU1.AA21 CPU1.W21 R1102.2
+V1.05S_ASATA3PLL: C1105.1 C1106.1 C1107.1 CPU1.B11 L1102.2 R1904.2 R1906.2
+V1.05S_AUSB3PLL: C1103.1 C1104.1 C1123.1 CPU1.B18 CPU1.B27 L1101.2 R1601.1
+V1.05S_AXCK_DCB: C1111.1 C1112.1 C1125.1 CPU1.J18 CPU1.K19 L1103.2
+V1.05S_AXCK_LCPLL: C1113.1 C1114.1 CPU1.A20 L1104.2 R1803.2
+V1.05S_CORE_PCH: C1117.1 C1118.1 C1119.1 CPU1.AE8 CPU1.AF22 CPU1.H11 CPU1.H15 CPU1.J11 R1105.2
+V1.05S_SSCF100: C2137.1 CPU1.J17 R2117.2
+V1.05S_SSCFF: C2138.1 CPU1.R21 CPU1.T21 R2118.2
+V3.3A_1.5A_HDA: C2116.1 CPU1.AH14 R2108.2
+V3.3A_DSW_P: C2101.1 C2136.1 CPU1.AH10 R2101.2
+V3.3A_PSUS: C1108.1 CPU1.AA9 CPU1.AC9 CPU1.AE20 CPU1.AE21 R1103.2
+V3.3S_1.8S_LPSS_SDIO: C2104.1 CPU1.T9 CPU1.U8 R2103.1
+V3.3S_PCORE: C2123.1 CPU1.V8 CPU1.W9 R2112.2
+VCCIOA_OUT: CPU1.E20 R801.1
+VCCRTCEXT: C2110.1 CPU1.AE7
AVCC33: C5517.1 C5523.2 R5504.2 U5502.24
GND: AFTP2501.1 AFTP2803.1 AFTP3906.1 AFTP3909.1 AFTP3910.1 AFTP6201.1 AFTP6217.1 AFTP6235.1 AFTP6245.1 AFTP6802.1 BAT1.6 BAT1.8 BAT1.9 BAT1.10 BAT1.11 C1.1 C2.1 C3.1 C701.2 C702.2 C703.2 C1001.2 C1002.2 C1003.2 C1004.2 C1005.2 C1006.2 C1017.2 C1018.2 C1019.2 C1020.2 C1101.2 C1102.2 C1103.2 C1104.2 C1105.2 C1106.2 C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1117.2 C1118.2 C1119.2 C1120.2 C1121.2 C1122.2 C1123.2 C1124.2 C1125.2 C1201.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1211.2 C1212.2 C1213.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1220.2 C1221.2 C1222.2 C1701.2 C1801.1 C1802.1 C1901.2 C1902.2 C1903.1 C1904.1 C2104.2 C2105.2 C2109.2 C2110.2 C2114.2 C2116.2 C2123.2 C2128.2 C2135.2 C2136.2 C2137.2 C2138.2 C2141.2 C2142.2 C2147.2 C2401.2 C2406.2 C2407.2 C2408.2 C2409.2 C2410.2 C2411.2 C2412.2 C2413.2 C2415.1 C2416.2 C2418.2 C2421.2 C2422.2 C2501.2 C2502.2 C2503.2 C2601.2 C2602.2 C2603.2 C2604.2 C2605.2 C2608.2 C2609.2 C2610.2 C2611.2 C2701.2 C2704.1 C2706.2 C2707.2 C2708.2 C2709.2 C2716.2 C2717.2 C2718.2 C2719.2 C2723.1 C2901.2 C3001.2 C3002.2 C3003.2 C3004.2 C3005.2 C3007.2 C3008.2 C3009.2 C3010.2 C3011.2 C3012.2 C3013.2 C3017.2 C3018.2 C3019.2 C3021.2 C3022.2 C3023.2 C3024.2 C3025.2 C3101.2 C3106.2 C3401.2 C3402.2 C3405.2 C3406.2 C3501.2 C3502.2 C3503.2 C3504.2 C3505.2 C3506.2 C3507.2 C3508.2 C3509.2 C3510.2 C3512.2 C3513.2 C3514.2 C3515.2 C3516.2 C3517.2 C3518.2 C3601.2 C3602.2 C3603.2 C3604.2 C3605.2 C3801.2 C3802.2 C5201.2 C5202.2 C5204.2 C5205.1 C5206.1 C5207.2 C5208.2 C5214.2 C5501.2 C5502.2 C5503.2 C5504.2 C5506.2 C5507.2 C5509.2 C5510.2 C5511.2 C5512.2 C5513.2 C5514.2 C5515.2 C5516.2 C5517.2 C5518.2 C5519.2 C5520.2 C5521.1 C5522.2 C5523.1 C5524.2 C5605.2 C5606.2 C5609.2 C5610.2 C5802.2 C5803.2 C5804.2 C5807.2 C6201.2 C6202.2 C6203.2 C6401.2 C6402.2 C7309.2 C7310.2 C7311.2 C7312.2 C7313.2 C7314.2 C7315.2 C7316.2 C7317.2 C7318.2 C7319.2 C7320.2 C7321.2 C7322.2 C7323.2 C7324.2 C7325.2 C7326.2 C7327.2 C7328.2 C7501.2 C7502.2 C7503.2 C7504.2 C7505.2 C7506.2 C7507.2 C7511.2 C7513.2 C7514.2 C7515.2 C7516.2 C7517.1 C7518.2 C7519.2 C7520.2 C7521.2 C7525.2 C7526.2 C7527.2 C7528.2 C7530.2 C7531.2 C7601.2 C7602.2 C7603.2 C7604.2 C7605.2 C7606.2 C7607.1 C7608.1 C7609.2 C7610.2 C7701.2 C7702.2 C7703.2 C7708.2 C7709.2 C7710.2 C7711.2 C7712.2 C7713.2 C7714.2 C7717.2 C7719.2 C7720.2 C7721.2 C7722.2 C7723.2 C7724.2 C7725.2 C7726.2 C7727.2 C7728.2 C7729.2 C7730.2 C7731.2 C7732.2 C7733.2 C7734.2 C7803.2 C7804.2 C7805.2 C7810.2 C7811.2 C7812.2 C7813.2 C7814.2 C7815.2 C7816.2 C7817.2 C7820.2 C7821.2 C7822.2 C7827.2 C7829.2 C7830.2 C7831.2 C7832.2 C7833.2 C7834.2 C7835.2 C7836.2 C7902.2 C7906.2 C7909.2 C7910.2 C7911.2 C7912.2 C7913.2 C7915.2 C7916.2 C7917.2 C7918.2 C7919.2 C7920.2 C7921.2 C7922.2 C7923.2 C7924.2 C7925.2 C7926.2 C7927.2 C7928.2 C7929.2 C7930.2 C8302.2 C8303.2 C8304.2 C8305.2 C8306.1 C8307.2 C8308.2 C8309.1 C8310.2 C8311.2 C8316.2 C9602.2 CCD1.8 CCD1.9 CCD1.10 CON1.7 CON1.10 CON1.13 CON1.16 CON1.17 CON1.18 CPU1.A11 CPU1.A14 CPU1.A18 CPU1.A24 CPU1.A28 CPU1.A32 CPU1.A36 CPU1.A40 CPU1.A44 CPU1.A48 CPU1.A52 CPU1.A56 CPU1.AA1 CPU1.AA58 CPU1.AB7 CPU1.AB10 CPU1.AB20 CPU1.AB22 CPU1.AC61 CPU1.AD3 CPU1.AD21 CPU1.AD63 CPU1.AE5 CPU1.AE10 CPU1.AE58 CPU1.AF11 CPU1.AF12 CPU1.AF14 CPU1.AF15 CPU1.AF17 CPU1.AF18 CPU1.AG1 CPU1.AG11 CPU1.AG21 CPU1.AG23 CPU1.AG60 CPU1.AG61 CPU1.AG62 CPU1.AG63 CPU1.AH16 CPU1.AH17 CPU1.AH19 CPU1.AH20 CPU1.AH22 CPU1.AH24 CPU1.AH28 CPU1.AH30 CPU1.AH32 CPU1.AH34 CPU1.AH36 CPU1.AH38 CPU1.AH40 CPU1.AH42 CPU1.AH44 CPU1.AH46 CPU1.AH49 CPU1.AH51 CPU1.AH53 CPU1.AH55 CPU1.AH57 CPU1.AJ13 CPU1.AJ14 CPU1.AJ23 CPU1.AJ25 CPU1.AJ27 CPU1.AJ29 CPU1.AJ35 CPU1.AJ39 CPU1.AJ41 CPU1.AJ43 CPU1.AJ45 CPU1.AJ47 CPU1.AJ50 CPU1.AJ52 CPU1.AJ54 CPU1.AJ56 CPU1.AJ58 CPU1.AJ60 CPU1.AJ63 CPU1.AK3 CPU1.AK23 CPU1.AK52 CPU1.AL10 CPU1.AL13 CPU1.AL17 CPU1.AL20 CPU1.AL22 CPU1.AL23 CPU1.AL26 CPU1.AL29 CPU1.AL31 CPU1.AL33 CPU1.AL36 CPU1.AL39 CPU1.AL40 CPU1.AL45 CPU1.AL46 CPU1.AL51 CPU1.AL52 CPU1.AL54 CPU1.AL57 CPU1.AL60 CPU1.AL61 CPU1.AM1 CPU1.AM17 CPU1.AM23 CPU1.AM31 CPU1.AM52 CPU1.AN7 CPU1.AN17 CPU1.AN23 CPU1.AN31 CPU1.AN32 CPU1.AN35 CPU1.AN36 CPU1.AN39 CPU1.AN40 CPU1.AN42 CPU1.AN43 CPU1.AN45 CPU1.AN46 CPU1.AN48 CPU1.AN49 CPU1.AN51 CPU1.AN52 CPU1.AN60 CPU1.AN63 CPU1.AP3 CPU1.AP10 CPU1.AP17 CPU1.AP20 CPU1.AP22 CPU1.AP23 CPU1.AP26 CPU1.AP29 CPU1.AP31 CPU1.AP38 CPU1.AP39 CPU1.AP48 CPU1.AP52 CPU1.AP54 CPU1.AP57 CPU1.AR5 CPU1.AR11 CPU1.AR15 CPU1.AR17 CPU1.AR23 CPU1.AR31 CPU1.AR33 CPU1.AR39 CPU1.AR43 CPU1.AR49 CPU1.AR52 CPU1.AT13 CPU1.AT35 CPU1.AT37 CPU1.AT40 CPU1.AT42 CPU1.AT43 CPU1.AT46 CPU1.AT49 CPU1.AT61 CPU1.AT62 CPU1.AT63 CPU1.AU1 CPU1.AU16 CPU1.AU18 CPU1.AU20 CPU1.AU22 CPU1.AU24 CPU1.AU26 CPU1.AU28 CPU1.AU30 CPU1.AU33 CPU1.AU51 CPU1.AU53 CPU1.AU55 CPU1.AU57 CPU1.AU59 CPU1.AV8 CPU1.AV14 CPU1.AV16 CPU1.AV20 CPU1.AV24 CPU1.AV28 CPU1.AV33 CPU1.AV34 CPU1.AV36 CPU1.AV39 CPU1.AV41 CPU1.AV43 CPU1.AV46 CPU1.AV49 CPU1.AV51 CPU1.AV55 CPU1.AV59 CPU1.AW4 CPU1.AW16 CPU1.AW24 CPU1.AW33 CPU1.AW35 CPU1.AW37 CPU1.AW40 CPU1.AW42 CPU1.AW44 CPU1.AW47 CPU1.AW50 CPU1.AW51 CPU1.AW59 CPU1.AW60 CPU1.AY4 CPU1.AY6 CPU1.AY11 CPU1.AY16 CPU1.AY18 CPU1.AY22 CPU1.AY24 CPU1.AY26 CPU1.AY30 CPU1.AY33 CPU1.AY51 CPU1.AY53 CPU1.AY57 CPU1.AY59 CPU1.B4 CPU1.B20 CPU1.B24 CPU1.B26 CPU1.B28 CPU1.B32 CPU1.B36 CPU1.B40 CPU1.B44 CPU1.B48 CPU1.B52 CPU1.B56 CPU1.B60 CPU1.C11 CPU1.C14 CPU1.C18 CPU1.C20 CPU1.C25 CPU1.C27 CPU1.C38 CPU1.C39 CPU1.C57 CPU1.D2 CPU1.D5 CPU1.D8 CPU1.D12 CPU1.D14 CPU1.D18 CPU1.D21 CPU1.D23 CPU1.D25 CPU1.D26 CPU1.D27 CPU1.D29 CPU1.D30 CPU1.D31 CPU1.D33 CPU1.D34 CPU1.D35 CPU1.D37 CPU1.D38 CPU1.D39 CPU1.D41 CPU1.D42 CPU1.D43 CPU1.D45 CPU1.D46 CPU1.D47 CPU1.D49 CPU1.D50 CPU1.D51 CPU1.D53 CPU1.D54 CPU1.D55 CPU1.D57 CPU1.D59 CPU1.D62 CPU1.D63 CPU1.E11 CPU1.E17 CPU1.F20 CPU1.F26 CPU1.F30 CPU1.F34 CPU1.F38 CPU1.F42 CPU1.F46 CPU1.F50 CPU1.F54 CPU1.F58 CPU1.F61 CPU1.G3 CPU1.G5 CPU1.G6 CPU1.G8 CPU1.G18 CPU1.G22 CPU1.H13 CPU1.H17 CPU1.H57 CPU1.J10 CPU1.J22 CPU1.J59 CPU1.J63 CPU1.K1 CPU1.K12 CPU1.L7 CPU1.L13 CPU1.L15 CPU1.L17 CPU1.L18 CPU1.L20 CPU1.L58 CPU1.L61 CPU1.M22 CPU1.N3 CPU1.N10 CPU1.N21 CPU1.P22 CPU1.P59 CPU1.P62 CPU1.P63 CPU1.R8 CPU1.R10 CPU1.R22 CPU1.T1 CPU1.T58 CPU1.U9 CPU1.U20 CPU1.U22 CPU1.U61 CPU1.V3 CPU1.V7 CPU1.V10 CPU1.V23 CPU1.V58 CPU1.W20 CPU1.W22 CPU1.Y10 CPU1.Y59 CPU1.Y63 CRT1.5 CRT1.6 CRT1.7 CRT1.8 CRT1.10 CRT1.16 CRT1.17 D2601.A D4301.1 D4302.1 D4303.1 DB1.8 DB1.10 DB1.11 DB1.12 DM1.2 DM1.3 DM1.8 DM1.9 DM1.11 DM1.13 DM1.14 DM1.19 DM1.20 DM1.25 DM1.26 DM1.28 DM1.31 DM1.32 DM1.37 DM1.38 DM1.43 DM1.44 DM1.46 DM1.48 DM1.49 DM1.54 DM1.55 DM1.60 DM1.61 DM1.63 DM1.65 DM1.66 DM1.71 DM1.72 DM1.127 DM1.128 DM1.133 DM1.134 DM1.136 DM1.138 DM1.139 DM1.144 DM1.145 DM1.150 DM1.151 DM1.153 DM1.155 DM1.156 DM1.161 DM1.162 DM1.167 DM1.168 DM1.170 DM1.172 DM1.173 DM1.178 DM1.179 DM1.184 DM1.185 DM1.187 DM1.189 DM1.190 DM1.195 DM1.196 DM1.205 DM1.206 EC701.2 EC702.2 EC1501.2 EC1502.2 EC1701.1 EC1702.2 EC1703.2 EC1704.2 EC1705.2 EC1706.2 EC1707.2 EC1801.2 EC1802.2 EC1901.1 EC2501.2 EC2502.2 EC2503.2 EC2601.2 EC2602.2 EC2701.2 EC2703.2 EC2704.2 EC2705.2 EC2706.2 EC2707.2 EC2708.2 EC2709.2 EC2901.2 EC2902.2 EC2903.2 EC2904.2 EC3101.1 EC3102.1 EC3103.1 EC3104.1 EC3105.1 EC3106.1 EC3107.1 EC3108.1 EC4301.2 EC4302.2 EC4303.2 EC4304.2 EC4305.1 EC4401.2 EC4402.2 EC4601.2 EC4701.2 EC5205.2 EC5206.2 EC5210.2 EC6103.2 EC6104.2 EC6105.2 EC6201.2 EC6202.2 EC6203.2 EC6204.2 EC6205.2 EC6206.2 EC9701.2 EC9702.2 EC9703.2 EC9704.2 EC9705.2 EC9706.2 EC9707.2 EC9708.2 EC9709.2 EC9710.2 EC9711.2 EC9712.2 EC9713.2 EC9714.2 EC9715.2 EC9716.2 EC9717.2 EC9718.2 EC9719.2 EC9720.2 EC9721.2 EC9722.2 EC9723.2 EC9724.2 EC9725.2 EC9726.2 EC9727.2 EC9728.2 EC9729.2 EC9730.2 EC9731.2 EC9732.2 EC9733.2 EC9734.2 EC9735.2 EC9736.2 EC9737.2 EC9738.2 EC9739.2 EC9740.2 EC9741.1 EC9742.2 EC9743.2 EC9744.2 EC9745.2 EC9747.1 EC9748.2 EC9749.1 ED2901.1 ED2902.1 ED2903.1 ED2904.1 ED2905.1 EL4203.2 FAN1.2 FAN1.4 FAN1.5 FAN261.5 FAN261.6 FAN261.7 FAN261.8 G1901.1 GPU1.A2 GPU1.A26 GPU1.AA7 GPU1.AB7 GPU1.AB11 GPU1.AB14 GPU1.AB17 GPU1.AB20 GPU1.AB24 GPU1.AC2 GPU1.AC5 GPU1.AC8 GPU1.AC22 GPU1.AC26 GPU1.AD12 GPU1.AD13 GPU1.AD15 GPU1.AD16 GPU1.AD18 GPU1.AD19 GPU1.AD21 GPU1.AD22 GPU1.AE11 GPU1.AE14 GPU1.AE17 GPU1.AE20 GPU1.AF1 GPU1.AF5 GPU1.AF8 GPU1.AF11 GPU1.AF14 GPU1.AF17 GPU1.AF20 GPU1.AF23 GPU1.AG2 GPU1.AG26 GPU1.B1 GPU1.B5 GPU1.B8 GPU1.B11 GPU1.B14 GPU1.B17 GPU1.B20 GPU1.B23 GPU1.B27 GPU1.E2 GPU1.E5 GPU1.E8 GPU1.E11 GPU1.E14 GPU1.E17 GPU1.E20 GPU1.E22 GPU1.E25 GPU1.H2 GPU1.H5 GPU1.H23 GPU1.H25 GPU1.K11 GPU1.K13 GPU1.K15 GPU1.K17 GPU1.L2 GPU1.L5 GPU1.L10 GPU1.L12 GPU1.L14 GPU1.L16 GPU1.L18 GPU1.L23 GPU1.L25 GPU1.M11 GPU1.M13 GPU1.M15 GPU1.M17 GPU1.N10 GPU1.N12 GPU1.N14 GPU1.N16 GPU1.N18 GPU1.P2 GPU1.P5 GPU1.P11 GPU1.P13 GPU1.P15 GPU1.P17 GPU1.P23 GPU1.P26 GPU1.R10 GPU1.R12 GPU1.R14 GPU1.R16 GPU1.R18 GPU1.T11 GPU1.T13 GPU1.T15 GPU1.T17 GPU1.U2 GPU1.U5 GPU1.U10 GPU1.U12 GPU1.U14 GPU1.U16 GPU1.U18 GPU1.U23 GPU1.U26 GPU1.V11 GPU1.V13 GPU1.V15 GPU1.V17 GPU1.Y2 GPU1.Y5 GPU1.Y23 GPU1.Y26 H1.1 H2.1 H3.1 H4.1 H5.1 H6.1 HDA27.4 HDA27.49 HDD1.23 HDD1.24 HDD1.P4 HDD1.P5 HDD1.P6 HDD1.P10 HDD1.P12 HDD1.S1 HDD1.S4 HDD1.S7 KB1.1 KB1.31 KB1.32 KB2.1 KB2.31 KB2.32 KBC24.5 KBC24.18 KBC24.45 KBC24.78 KBC24.89 KBC24.116 KBLIT1.5 KBLIT1.6 LCD1.13 LCD1.16 LCD1.19 LCD1.23 LCD1.24 LCD1.25 LCD1.29 LCD1.36 LCD1.41 LCD1.42 LIDSW1.1 LOM30.33 ODD1.5 ODD1.6 ODD1.14 ODD1.15 ODD1.S1 ODD1.S4 ODD1.S7 PC4202.2 PC4203.2 PC4204.2 PC4205.2 PC4206.2 PC4209.2 PC4401.2 PC4406.2 PC4407.2 PC4408.2 PC4409.2 PC4415.2 PC4416.2 PC4417.2 PC4418.2 PC4419.2 PC4425.2 PC4426.2 PC4427.2 PC4431.2 PC4509.2 PC4515.2 PC4517.2 PC4518.2 PC4519.2 PC4520.2 PC4521.2 PC4524.2 PC4525.2 PC4526.2 PC4527.2 PC4528.2 PC4529.2 PC4530.2 PC4531.2 PC4533.2 PC4534.2 PC4536.2 PC4604.2 PC4606.2 PC4609.1 PC4610.2 PC4611.2 PC4612.2 PC4613.1 PC4701.2 PC4702.2 PC4703.2 PC4704.2 PC4710.2 PC4717.2 PC4718.2 PC4719.2 PC4720.2 PC4721.2 PC4722.2 PC4723.2 PC4724.2 PC4725.2 PC4726.2 PC4727.2 PC4728.2 PC4729.2 PC4730.2 PC4731.2 PC4732.2 PC4733.2 PC4734.2 PC4735.2 PC4736.2 PC4737.2 PC4738.2 PC4739.2 PC4740.2 PC4741.2 PC4742.2 PC4743.2 PC4744.2 PC4814.2 PC4815.2 PC4821.2 PC4824.2 PC4825.2 PC4826.2 PC4838.2 PC4901.2 PC4902.2 PC4903.2 PC4904.2 PC4906.2 PC4909.2 PC4911.2 PC4912.2 PC4913.1 PC4914.2 PC4915.2 PC4916.2 PC4917.2 PC4918.2 PC4920.2 PC4921.2 PC4922.2 PC4923.2 PC4924.2 PC4925.2 PC4926.2 PC5101.2 PC5108.2 PC5109.2 PC5112.2 PC5113.2 PC5114.2 PC5115.2 PC5116.2 PC5117.2 PC5118.2 PC5119.2 PC5120.2 PC8202.1 PC8203.1 PC8205.2 PC8206.2 PC8207.2 PC8208.2 PC8209.2 PC8210.2 PC8212.2 PC8213.2 PC8214.2 PC8215.2 PC8217.2 PC8218.2 PC8220.1 PC8221.1 PC8222.2 PC8224.2 PC8225.1 PC8226.1 PC8302.2 PC8303.2 PC8307.2 PD4201.A PD4203.1 PD4204.3 PD4302.A PD4501.A PG4411.2 PQ4202.E PQ4203.1 PQ4203.4 PQ4204.E PQ4206.1 PQ4206.4 PQ4208.S PQ4402.1 PQ4402.4 PQ4408.1 PQ4408.4 PQ4410.1 PQ4410.4 PQ4414.S PQ8304.1 PQ8304.4 PQ8305.1 PQ8305.4 PQ8306.S PQ8307.S PR4202.2 PR4208.2 PR4213.2 PR4216.2 PR4218.2 PR4405.2 PR4432.2 PR4433.2 PR4436.2 PR4464.2 PR4467.2 PR4470.1 PR4474.2 PR4517.2 PR4523.2 PR4526.2 PR4530.2 PR4531.2 PR4604.2 PR4607.1 PR4610.1 PR4614.1 PR4617.2 PR4622.2 PR4707.2 PR4817.1 PR4823.2 PR4824.2 PR4902.2 PR4906.2 PR4908.1 PR5103.2 PR5104.2 PR5111.2 PR8213.2 PR8224.2 PR8259.2 PT4501.2 PT4502.2 PT4701.2 PT4702.2 PT4803.2 PT8206.2 PT8207.2 PT8208.2 PU4404.14 PU4406.1 PU4406.2 PU4406.3 PU4407.1 PU4407.2 PU4502.1 PU4502.2 PU4502.3 PU4503.21 PU4505.1 PU4505.2 PU4505.3 PU4601.21 PU4701.5 PU4701.6 PU4701.7 PU4805.1 PU4805.2 PU4805.3 PU4806.11 PU4901.4 PU4901.7 PU4901.10 PU4901.21 PU4903.1 PU4903.2 PU4903.3 PU5101.2 PU5102.9 PU8201.21 PU8203.1 PU8203.2 PU8203.3 PU8205.1 PU8205.2 PU8205.3 PU8207.1 PU8207.2 PU8207.3 PU8209.1 PU8209.2 PU8209.3 Q1701.1 Q1701.4 Q1901.S Q2401.S Q2403.S Q2404.C Q2505.S Q3001.S Q3601.1 Q3601.4 Q6202.S Q7603.1 Q7603.4 Q8301.S R402.2 R405.2 R406.2 R407.1 R408.1 R409.1 R601.1 R602.2 R603.1 R604.2 R605.2 R606.2 R709.2 R712.2 R901.2 R1201.2 R1202.2 R1204.2 R1509.1 R1511.2 R1602.2 R1715.2 R1717.2 R1721.2 R1725.1 R1902.2 R1913.1 R1920.1 R2003.2 R2008.2 R2024.2 R2026.2 R2435.1 R2442.2 R2447.2 R2449.1 R2504.2 R2605.1 R2611.2 R2706.2 R2717.2 R3015.2 R3023.2 R3032.1 R3501.2 R3502.2 R3602.2 R3605.2 R3703.2 R3707.2 R3709.2 R3711.2 R5201.2 R5202.1 R5207.2 R5209.2 R5501.2 R5505.2 R5508.1 R5510.2 R5512.1 R5513.2 R5514.2 R5516.1 R5604.2 R6207.2 R6208.2 R6211.2 R7301.2 R7302.2 R7306.2 R7506.2 R7507.1 R7508.2 R7509.2 R7510.2 R7511.2 R7512.2 R7518.2 R7601.2 R7602.2 R7607.1 R7609.2 R7610.2 R7614.2 R7616.2 R7618.2 R7620.2 R7621.2 R7622.2 R7627.2 R7628.1 R7632.2 R7637.2 R7640.2 R7641.2 R7642.2 R7651.2 R7807.2 R7808.1 R7809.1 R7904.2 R7912.1 R7913.1 R8301.2 R8305.2 RJ45.9 RJ45.10 RN1503.1(A) RN1503.2(A) RN1703.1(A) RN1703.2(A) RN1803.1(A) RN1803.2(A) RN1804.1(A) RN1804.2(A) RN5203.1(A) RN5203.2(A) RN5203.3(A) RN7401.1(A) RN7401.2(A) RN7402.1(A) RN7402.2(A) RN7403.1(A) RN7403.2(A) RN7404.1(A) RN7404.2(A) RN7602.1(A) RN7602.2(A) RTC1.2 S1.1 S2.1 SKT25.4 SPI25.4 SPK1.5 SPK1.6 SPR2.1 SPR3.1 SPR4.1 SPR5.1 SW1.1 SW1.2 SW1.5 SW1.6 TC1201.2 TC3501.2 TC3502.2 TC6301.2 THM26.5 TPAD1.5 TPAD1.9 TPAD1.10 U701.3 U2101.8 U2901.1 U3101.3 U3101.8 U3102.3 U3102.8 U3401.2 U3402.3 U3402.8 U3403.2 U3501.1 U3501.9 U3502.1 U3503.2 U3504.2 U3505.2 U3601.11 U3601.15 U3801.1 U5201.2 U5501.1 U5501.4 U5501.7 U5501.9 U5501.10 U5501.12 U5501.13 U5502.11 U5502.13 U5502.14 U5502.16 U5502.33 U5504.1 U5504.2 U5504.4 U5504.7 U5601.1 U5601.9 U5602.3 U5602.8 U7301.3 U8301.11 U8301.15 USB1.4 USB1.7 USB1.10 USB1.11 USB1.12 USB1.13 USB2.4 USB2.5 USB2.6 USB2.7 USB2.8 VRAM1.A9 VRAM1.B1 VRAM1.B3 VRAM1.B9 VRAM1.D1 VRAM1.D8 VRAM1.E1 VRAM1.E2 VRAM1.E8 VRAM1.F9 VRAM1.G1 VRAM1.G8 VRAM1.G9 VRAM1.J2 VRAM1.J8 VRAM1.M1 VRAM1.M9 VRAM1.P1 VRAM1.P9 VRAM1.T1 VRAM1.T9 VRAM2.A9 VRAM2.B1 VRAM2.B3 VRAM2.B9 VRAM2.D1 VRAM2.D8 VRAM2.E1 VRAM2.E2 VRAM2.E8 VRAM2.F9 VRAM2.G1 VRAM2.G8 VRAM2.G9 VRAM2.J2 VRAM2.J8 VRAM2.M1 VRAM2.M9 VRAM2.P1 VRAM2.P9 VRAM2.T1 VRAM2.T9 VRAM3.A9 VRAM3.B1 VRAM3.B3 VRAM3.B9 VRAM3.D1 VRAM3.D8 VRAM3.E1 VRAM3.E2 VRAM3.E8 VRAM3.F9 VRAM3.G1 VRAM3.G8 VRAM3.G9 VRAM3.J2 VRAM3.J8 VRAM3.M1 VRAM3.M9 VRAM3.P1 VRAM3.P9 VRAM3.T1 VRAM3.T9 VRAM4.A9 VRAM4.B1 VRAM4.B3 VRAM4.B9 VRAM4.D1 VRAM4.D8 VRAM4.E1 VRAM4.E2 VRAM4.E8 VRAM4.F9 VRAM4.G1 VRAM4.G8 VRAM4.G9 VRAM4.J2 VRAM4.J8 VRAM4.M1 VRAM4.M9 VRAM4.P1 VRAM4.P9 VRAM4.T1 VRAM4.T9 WLAN1.4 WLAN1.9 WLAN1.15 WLAN1.18 WLAN1.21 WLAN1.26 WLAN1.27 WLAN1.29 WLAN1.34 WLAN1.35 WLAN1.37 WLAN1.40 WLAN1.43 WLAN1.50 WLAN1.53 WLAN1.54 X7601.2 X7601.4
V3D3_STB: HDA27.20 R2712.1
VBAT: C2404.1 C2405.1 KBC24.102 R2402.1 R2404.1 R2405.1 R2445.1 R2446.1
VCC1R05VIDEO_PEX_PLLVDD: C7317.1 C7318.1 C7319.1 GPU1.AA14 GPU1.AA15 L7301.1
VCC_CORE: CPU1.AB57 CPU1.AD57 CPU1.AG57 CPU1.C24 CPU1.C28 CPU1.C32 CPU1.C36 CPU1.C40 CPU1.C44 CPU1.C48 CPU1.C52 CPU1.C56 CPU1.E23 CPU1.E25 CPU1.E27 CPU1.E29 CPU1.E31 CPU1.E33 CPU1.E35 CPU1.E37 CPU1.E39 CPU1.E41 CPU1.E43 CPU1.E45 CPU1.E47 CPU1.E49 CPU1.E51 CPU1.E53 CPU1.E55 CPU1.E57 CPU1.F24 CPU1.F28 CPU1.F32 CPU1.F36 CPU1.F40 CPU1.F44 CPU1.F48 CPU1.F52 CPU1.F56 CPU1.F59 CPU1.G23 CPU1.G25 CPU1.G27 CPU1.G29 CPU1.G31 CPU1.G33 CPU1.G35 CPU1.G37 CPU1.G39 CPU1.G41 CPU1.G43 CPU1.G45 CPU1.G47 CPU1.G49 CPU1.G51 CPU1.G53 CPU1.G55 CPU1.G57 CPU1.H23 CPU1.J23 CPU1.K23 CPU1.K57 CPU1.L22 CPU1.M23 CPU1.M57 CPU1.P57 CPU1.U57 CPU1.W57 EC4701.1 PC4717.1 PC4718.1 PC4719.1 PC4720.1 PC4721.1 PC4722.1 PC4723.1 PC4724.1 PC4725.1 PC4726.1 PC4727.1 PC4728.1 PC4729.1 PC4730.1 PC4731.1 PC4732.1 PC4733.1 PC4734.1 PC4735.1 PC4736.1 PC4737.1 PC4738.1 PC4739.1 PC4740.1 PC4741.1 PC4742.1 PC4743.1 PC4744.1 PG4702.2 PL4701.2 PT4701.1 R702.1
VCC_SENSE: CPU1.E63 PC4601.2 PC4613.2 PR4603.2 R702.2
VCCK_12: C5501.1 C5503.1 C5504.1 U5502.19 U5502.25
VCCST_PWRGD_XDP: R9601.2 TP9648.1
VDD10: C3012.1 C3018.1 C3019.1 C3021.1 C3022.1 C3023.1 C3024.1 C3025.1 L3001.2 LOM30.3 LOM30.8 LOM30.22 LOM30.30 R3001.2
VDD_DAC_33: C5502.1 C5521.2 C5524.1 R5503.2 U5502.9
VDDREG: C3009.1 C3010.1 LOM30.23 R3006.2
VSS_SENSE: CPU1.E62 PC4612.1 PR4604.1 PU4601.8 R901.1
0D675V_S0: C1214.1 C1215.1 C1216.1 DM1.203 DM1.204 PG4901.1 PG4902.1
1D05S_VCCST: C701.1 C703.1 CPU1.AC22 CPU1.AE22 CPU1.AE23 PC4606.1 PR4601.1 PR4620.2 PR4630.2 R401.1 R703.1 R704.1 R705.1 R706.1 R711.2 R1916.2 R1917.2 R1918.2 R1919.2 R2018.1 RN401.5(B) RN401.7(B) RN401.8(B)
1D05V_HSIO: C2142.1 L1101.1 L1102.1 R1101.1 R2114.2 R2122.2
1D05V_PWR: PC4824.1 PG4824.2 PG4825.2 PG4826.2 PG4828.2 PG4830.2 PG4831.2 PG4832.2 PL4801.2 PT4803.1
1D5V_PWR: PC5120.1 PG5105.1 PU5101.5
1D05V_S0: C2135.1 C2141.1 C8302.1 CPU1.AG13 CPU1.AG14 CPU1.AG16 CPU1.AG17 L1103.1 L1104.1 PG4824.1 PG4825.1 PG4826.1 PG4828.1 PG4830.1 PG4831.1 PR4602.1 R711.1 R1102.1 R1104.1 R1105.1 R2105.1 R2117.1 R2118.1 R2122.1 R2401.1 R3608.1 U2101.2 U2101.3 U2101.4 U8301.1 U8301.2
1D5V_S0: CPU1.J15 PG5105.2 R2705.1
1D05V_VGA_EN: C8309.2 PR8301.2 R8313.2 U8301.3
1D05V_VGA_OUT2: C8310.1 PG8313.1 PG8314.1 PG8315.1 U8301.13 U8301.14
1D05V_VGA_S0: C7309.1 C7310.1 C7311.1 C7312.1 C7313.1 C7314.1 C7320.1 C7321.1 C7322.1 C7323.1 C7325.1 C7326.1 C7327.1 C7328.1 C8306.2 GPU1.AA10 GPU1.AA12 GPU1.AA13 GPU1.AA16 GPU1.AA18 GPU1.AA19 GPU1.AA20 GPU1.AA21 GPU1.AA22 GPU1.AB22 GPU1.AB23 GPU1.AC23 GPU1.AC24 GPU1.AD24 GPU1.AD25 GPU1.AE25 GPU1.AE26 GPU1.AE27 GPU1.AF26 GPU1.AF27 L7301.2 L7501.2 L7601.1 L7602.1 PG8313.2 PG8314.2 PG8315.2 PR8316.1
1D05V_VGA_S0_DISCHG: PQ8305.3 PR8316.2
1D05V_VTT_PWRGD: PR4821.2 R707.1 R3611.1 U701.2
1D35V_ENABLE: PQ8304.3 PR8310.1 PR8312.1 R8314.2
1D35V_ENABLE_RC: PC8302.1 PQ8308.4 R8314.1
1D35V_PWR: EC4601.1 PC4904.1 PC4920.1 PC4921.1 PC4923.1 PC4924.1 PC4925.1 PC4926.1 PG4907.2 PG4908.2 PG4909.2 PG4910.2 PG4911.2 PG4912.2 PG4913.2 PG4914.2 PG4915.2 PG4916.2 PG4917.2 PG4918.2 PG4919.2 PG4920.2 PL4902.2 PU4901.2
1D35V_S3: C1001.1 C1002.1 C1003.1 C1004.1 C1005.1 C1006.1 C1017.1 C1018.1 C1019.1 C1020.1 C1207.1 C1208.1 C1209.1 C1210.1 C1211.1 C1212.1 C1213.1 C1220.1 C1221.1 C1222.1 CPU1.AH26 CPU1.AJ31 CPU1.AJ33 CPU1.AJ37 CPU1.AN33 CPU1.AP43 CPU1.AR48 CPU1.AY35 CPU1.AY40 CPU1.AY44 CPU1.AY50 DM1.75 DM1.76 DM1.81 DM1.82 DM1.87 DM1.88 DM1.93 DM1.94 DM1.99 DM1.100 DM1.105 DM1.106 DM1.111 DM1.112 DM1.117 DM1.118 DM1.123 DM1.124 PC8303.1 PG4908.1 PG4909.1 PG4910.1 PG4911.1 PG4912.1 PG4913.1 PG4914.1 PG4915.1 PG4916.1 PG4917.1 PG4918.1 PG4919.1 PG4920.1 PQ8308.5 PQ8308.6 PQ8308.7 PQ8308.8 Q1201.G Q1202.D R410.1 R3701.1 R3706.1 TC1201.1
1D35V_VGA_EN: D8301.3 PQ8304.2 PR5114.2 R8305.1 R8312.2
1D35V_VGA_EN#: PQ8304.5 PQ8304.6 PQ8306.G PR8311.2 PR8314.2
1D35V_VGA_S0: C7501.1 C7502.1 C7503.1 C7504.1 C7507.1 C7511.1 C7513.1 C7514.1 C7515.1 C7516.1 C7517.2 C7519.1 C7520.1 C7521.1 C7525.1 C7526.1 C7527.1 C7528.1 C7530.1 C7531.1 C7804.1 C7805.1 C7810.1 C7811.1 C7812.1 C7813.1 C7814.1 C7815.1 C7816.1 C7817.1 C7820.1 C7821.1 C7822.1 C7827.1 C7829.1 C7830.1 C7831.1 C7832.1 C7833.1 C7834.1 C7835.1 C7836.1 C7906.1 C7909.1 C7910.1 C7911.1 C7912.1 C7913.1 C7915.1 C7916.1 C7917.1 C7918.1 C7919.1 C7920.1 C7921.1 C7922.1 C7923.1 C7924.1 C7925.1 C7926.1 C7927.1 C7928.1 C7929.1 C7930.1 EC9725.1 EC9726.1 EC9727.1 EC9728.1 EC9729.1 EC9730.1 EC9731.1 GPU1.B26 GPU1.C25 GPU1.E23 GPU1.E26 GPU1.F14 GPU1.F21 GPU1.G13 GPU1.G14 GPU1.G15 GPU1.G16 GPU1.G18 GPU1.G19 GPU1.G20 GPU1.G21 GPU1.H24 GPU1.H26 GPU1.J21 GPU1.K21 GPU1.L22 GPU1.L24 GPU1.L26 GPU1.M21 GPU1.N21 GPU1.R21 GPU1.T21 GPU1.V21 GPU1.W21 PC5101.1 PC5108.1 PC5114.1 PC5116.1 PC5117.1 PC5118.1 PC8307.1 PG5104.2 PL5101.2 PQ8308.1 PQ8308.2 PQ8308.3 PR8315.1 R7501.2 R7503.2 R7505.2 R7806.1 R7903.1 VRAM1.A1 VRAM1.A8 VRAM1.B2 VRAM1.C1 VRAM1.C9 VRAM1.D2 VRAM1.D9 VRAM1.E9 VRAM1.F1 VRAM1.G7 VRAM1.H2 VRAM1.H9 VRAM1.K2 VRAM1.K8 VRAM1.N1 VRAM1.N9 VRAM1.R1 VRAM1.R9 VRAM2.A1 VRAM2.A8 VRAM2.B2 VRAM2.C1 VRAM2.C9 VRAM2.D2 VRAM2.D9 VRAM2.E9 VRAM2.F1 VRAM2.G7 VRAM2.H2 VRAM2.H9 VRAM2.K2 VRAM2.K8 VRAM2.N1 VRAM2.N9 VRAM2.R1 VRAM2.R9 VRAM3.A1 VRAM3.A8 VRAM3.B2 VRAM3.C1 VRAM3.C9 VRAM3.D2 VRAM3.D9 VRAM3.E9 VRAM3.F1 VRAM3.G7 VRAM3.H2 VRAM3.H9 VRAM3.K2 VRAM3.K8 VRAM3.N1 VRAM3.N9 VRAM3.R1 VRAM3.R9 VRAM4.A1 VRAM4.A8 VRAM4.B2 VRAM4.C1 VRAM4.C9 VRAM4.D2 VRAM4.D9 VRAM4.E9 VRAM4.F1 VRAM4.G7 VRAM4.H2 VRAM4.H9 VRAM4.K2 VRAM4.K8 VRAM4.N1 VRAM4.N9 VRAM4.R1 VRAM4.R9
1D35V_VTT_PWRGD: PR4904.2 PU4901.20 R3610.1
3D3V_AUX_KBC: D4301.2 D4302.2 D4303.2 PR4412.1 PR4415.1 PR4439.1 PR8314.1 Q2402.D R2402.2 R2403.2 R2413.2 R2414.2 R2418.2 R2426.2 R2434.1 R2436.1 R2452.2 R2453.2 R2607.1 R2608.1 RN2401.1(A) RN2401.2(A)
3D3V_AUX_KBC_VCC: C2406.1 C2407.1 C2408.1 C2409.1 C2410.1 C2411.1 KBC24.19 KBC24.46 KBC24.76 KBC24.88 KBC24.115 R2403.1
3D3V_AUX_S5: C2417.2 D2501.1 KBC24.75 PR4417.1 PR4419.1 PR4434.1 PR4435.1 PR4438.2 PR4501.1 PR4532.2 PR8311.1 PR8313.1 Q2402.S R1726.2 R1727.1 R2425.2 R2431.2 R2434.2 R2439.1 R2609.1 R3607.1
3D3V_CAMERA_S0: AFTP5227.1 C5207.1 CCD1.1 EC5210.1 LCD1.32 R5229.2
3D3V_LAN_S5: C3003.1 C3004.1 C3005.1 C3007.1 C3008.1 C3017.1 LOM30.11 LOM30.32 Q3004.D R3003.1 R3004.1 R3006.1 RN3001.1(A) RN3001.2(A)
3D3V_PWR: PC4517.1 PG4517.1 PG4522.1 PG4526.1 PG4528.1 PG4529.1 PG4535.1 PL4502.1 PT4502.1
3D3V_PWR_2: PC4526.1 PR4532.1 PU4503.3
3D3V_S0: C1203.1 C2128.1 C2412.1 C2413.1 C2601.1 C2602.1 C3605.1 C5204.1 C5520.1 C5522.1 C5802.1 C5803.1 C5804.1 C8301.1 C8304.1 C8311.1 CON1.5 CPU1.K14 CPU1.K16 DB1.1 DM1.199 EC9735.1 EC9736.1 EC9737.1 EC9738.1 KBC24.4 PR4904.1 Q1801.2 Q1801.5 Q2601.2 Q2601.5 Q8302.S R1510.1 R1701.1 R1714.2 R1905.1 R2005.1 R2006.1 R2007.2 R2011.1 R2012.1 R2023.1 R2025.1 R2103.2 R2112.1 R2415.2 R2443.2 R2603.1 R2604.1 R2701.1 R2710.1 R2914.1 R3014.1 R3601.1 R4622.1 R5208.1 R5229.1 R5231.1 R5502.2 R5503.1 R5504.1 R5509.2 R5515.2 R5607.1 R6212.1 R6217.1 R7648.2 R7650.2 R8302.1 RN1501.1(A) RN1501.2(A) RN1505.1(A) RN1505.2(A) RN1505.3(A) RN1505.4(A) RN1801.1(A) RN1801.2(A) RN1801.3(A) RN1801.4(A) RN1810.1(A) RN1810.2(A) RN1902.5(B) RN1902.6(B) RN1902.7(B) RN1902.8(B) RN2002.1(A) RN2002.2(A) RN2002.3(A) RN2002.4(A) RN2007.3(B) RN2007.4(B) RN2008.3(B) RN2008.4(B) RN2011.1(A) RN2011.2(A) RN2011.3(A) RN2011.4(A) RN2602.1(A) RN2602.2(A) THM26.1 U3601.8 U3601.9 U5201.4 U5201.5 U5502.5 U5502.20 U5504.3 U5504.8 U8301.6 U8301.7 WLAN1.2 WLAN1.24 WLAN1.39 WLAN1.41 WLAN1.52
3D3V_S5: C702.1 C2147.1 C2501.1 C2502.1 C3013.1 C3015.1 C3801.1 C6402.1 CPU1.Y8 LIDSW1.2 PC5109.1 PC5119.1 PD4203.2 PG4517.2 PG4522.2 PG4526.2 PG4528.2 PG4529.2 PR4204.1 PR4211.2 PR4472.1 PR4473.2 PR4534.1 PR5112.1 PU5101.1 Q3004.S R1703.1 R2101.1 R2412.2 R2421.2 R2501.2 R2712.2 R3021.1 R3033.2 R3801.1 R6213.1 R6401.2 RN1701.1(A) RN1701.2(A) RN1802.1(A) RN1802.2(A) RN2006.1(A) RN2006.2(A) RN2501.3(B) RN2501.4(B) SKT25.8 SPI25.8 U701.5 U3601.6 U3601.7 U3801.2 U3801.3
3D3V_S5_PCH: C3802.1 R1103.1 R1724.1 R2010.1 R2013.2 R2014.1 R2015.1 R2102.2 R2108.1 R3801.2 RN1601.1(A) RN1601.2(A) RN1601.3(A) RN1601.4(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) RN1809.1(A) RN1809.2(A) RN1809.3(A) RN1809.4(A) RN1811.1(A) RN1811.2(A) RN2012.1(A) RN2012.2(A) RN2012.3(A) RN2012.4(A) U3801.6 U3801.7 U3801.8
3D3V_VGA_OUT1: PG8312.1 U8301.8 U8301.9
3D3V_VGA_S0: C7703.1 C7727.1 C7728.1 C7729.1 C7734.1 C8303.1 GPU1.G8 GPU1.G9 PR8256.1 PR8301.1 Q8302.D R7608.1 R7611.1 R7619.1 R7626.2 R7638.1 R7639.1 R7647.2 R8304.2
27MHZ_IN: C7607.2 GPU1.C11 R7603.1 X7601.1
27MHZ_OUT: GPU1.B10 R7603.2 R7604.2
27MHZ_OUT_R: C7608.2 R7604.1 X7601.3
+0D675V_DDR_P: PC4915.1 PC4916.1 PC4917.1 PG4901.2 PG4902.2 PU4901.1 PU4901.3
+1.05M_ASW: C1115.1 C1116.1 CPU1.AE9 CPU1.AF9 CPU1.AG8 R1104.2
+3.3A_DSW_PRTCSUS: C2109.1 CPU1.AH11 R2102.1
+DC_IN: EL4201.2 EL4202.2 PC4201.1 PC4202.1 PD4201.K PQ4205.E PR4207.1 PR4212.1 PR4214.1 PU4201.1 PU4201.2 PU4201.3
+DC_IN_C: AFTP3801.1 AFTP3805.1 DCIN1.1 DCIN1.2 DCIN1.3 EC4201.1 EC4202.1 EL4201.1 EL4202.1
+PCH_VCCDSW: C2101.2 CPU1.AG19 CPU1.AG20 R2110.1
+PWR_SRC_1D35V: PC4909.1 PC4911.1 PC4912.1 PC4913.2 PC4914.1 PG4903.1 PG4904.1 PG4905.1 PG4906.1 PU4902.5 PU4902.6 PU4902.7 PU4902.8
+RTC_VCC: AFTP2502.1 R2502.2 RTC1.1
+V_SM_VREF_CNT: C3701.1 CPU1.AP49 R3708.2
+V_VREF_PATH1: C3702.2 R3711.1
+V_VREF_PATH3: C3701.2 R3707.1
+VCHGR_R: PG4405.1 PR4454.1
AC_IN#: PC4401.1 PQ4408.5 PR4425.2 PR4433.1 PR4434.2 PU4404.5 R2413.1 R2430.1
AC_IN#_G: PQ4206.2 PR4212.2 PR4213.1
AC_IN_KBC#: KBC24.65 PQ4206.6 R2426.1
AC_PRESENT: CPU1.AJ8 D7601.K EC1707.1 KBC24.112 RN1701.3(B)
AD+: PC4203.1 PC4204.1 PC4205.1 PC4206.1 PR4404.1 PR4405.1 PR4407.1 PR4408.1 PR4469.1 PU4201.5 PU4201.6 PU4201.7 PU4201.8 PU4402.5 PU4402.6 PU4402.7 PU4402.8 PU4403.4
AD+_G_1: PQ4402.5 PQ4402.6 PR4401.1
AD+_G_2: PR4401.2 PR4403.2 PU4402.4
AD+_TO_SYS: PG4402.1 PR4402.1 PR4403.1 PU4402.1 PU4402.2 PU4402.3
AD_IA: C2414.2 KBC24.97 PR4422.2
AD_IA_HW: KBC24.105 PQ4407.5
AD_IA_HW2: KBC24.25 PQ4407.2
AD_OFF_L: PQ4204.C PQ4205.B
AD_OFF_R: PC4201.2 PC4208.1 PQ4205.C PR4207.2 PR4208.1 PU4201.4
ALERT#: R2603.2 THM26.6
ALL_SYS_PWRGD: KBC24.10 R3601.2 R3610.2 R3611.2
AMBER_LED_BAT: EC6105.1 Q6104.C R6103.2
AMP_MUTE#: KBC24.30 R2708.1
AUD_AGND: AFTP2908.1 C2702.1 C2705.1 C2710.2 C2711.2 C2712.1 C2713.2 C2715.2 C2902.2 EC2703.1 EC2704.1 EC2705.1 EC2706.1 EC2707.1 EC2905.2 EC2906.2 EC2907.2 EC2908.2 EC9739.1 EC9743.1 EC9744.1 EC9745.1 HDA27.25 HDA27.38 HPMIC1.MS Q2901.S R2706.1 R2707.2 R2711.1 R2905.2 R2916.2 R2919.2 R2920.2 U2901.4
AUD_HP1_JACK_L: HDA27.32 R2908.1
AUD_HP1_JACK_L1: EC2907.1 R2907.2 R2908.2 R2912.2 R2919.1 R2922.2
AUD_HP1_JACK_R: HDA27.33 R2910.1
AUD_HP1_JACK_R1: EC2908.1 R2909.2 R2910.2 R2913.2 R2920.1 R2921.2
AUD_PC_BEEP: C2720.2 HDA27.12
AUD_PC_BEEP_C: C2720.1 D2701.3 R2717.1
AUD_PORTA_L_R_B: AFTP2906.1 ED2902.2 HPMIC1.1 R2907.1
AUD_PORTA_R_R_B: AFTP2907.1 ED2901.2 HPMIC1.2 R2909.1
AUD_SENSE: AFTP2909.1 ED2904.2 Q2901.D R2709.2 R2923.2
AUD_SENSE_A: HDA27.13 R2709.1 R2722.2
AUD_SPK_L+: EC2902.1 HDA27.42 R2902.2
AUD_SPK_L+_C: AFTP2902.1 R2902.1 SPK1.3
AUD_SPK_L-: EC2901.1 HDA27.43 R2901.2
AUD_SPK_L-_C: AFTP2901.1 R2901.1 SPK1.4
AUD_SPK_R+: EC2904.1 HDA27.45 R2904.2
AUD_SPK_R+_C: AFTP2904.1 R2904.1 SPK1.1
AUD_SPK_R-: EC2903.1 HDA27.44 R2903.2
AUD_SPK_R-_C: AFTP2903.1 R2903.1 SPK1.2
AUD_VREF: C2705.2 HDA27.28
BAT_ALERT: AFTP3901.1 BAT1.7
BAT_AMBER: CON1.14 R6103.1
BAT_IN#: D4302.3 EC4305.2 KBC24.80 PC4210.2 PC4433.1 PQ4203.2 PR4215.2 PR4216.1 PR4472.2 R2414.1 RN4301.1(A)
BAT_SCL: D4301.3 EC4301.1 KBC24.70 PG4407.2 PR4415.2 RN2401.3(B) RN4301.3(A)
BAT_SDA: D4303.3 EC4302.1 KBC24.69 PG4408.2 PR4412.2 RN2401.4(B) RN4301.2(A)
BAT_WHITE: CON1.15 R6101.1
BATLOW#: CPU1.AN4 RN2006.4(B)
BATT_WHITE_LED#: KBC24.62 R6105.1
BATT_WHITE_LED_R#: Q6103.B R6105.2
BKLT_CTRL: D5202.3 R5222.1 RN5201.7(B) RN5203.8(B)
BLON_OUT: KBC24.27 RN5201.6(B)
BLON_OUT_C: AFTP5205.1 LCD1.21 RN5201.3(A) RN5203.7(B)
BLUETOOTH_EN: CPU1.J4 R5805.1 R5806.2 RN2011.5(B)
BOARD_ID1: CPU1.U4 R2023.2 R2024.1
BOARD_ID2: CPU1.Y3 R2005.2 R2008.1
BOARD_ID3: CPU1.P3 R2025.2 R2026.1
BOOST_10V: PC4534.1 PD4502.1 PD4503.2
BOOST_MODE#: KBC24.20 PR4418.1 PR4435.2 PR4439.2
BOOST_MON: KBC24.96 PR4452.1
BOOST_MON_1: PC4427.1 PR4446.1 PR4452.2
BP_PWRGD_RST#: R9603.2 TP9645.1
BST15V_1: PC4514.2 PD4503.3
BST15V_2: PC4532.2 PD4502.3
BT+: AFTP3905.1 AFTP3907.1 AFTP3908.1 BAT1.1 BAT1.2 EC4303.1 EC4304.1 PC4415.1 PC4416.1 PC4417.1 PC4418.1 PC4419.1 PD4302.K PG4405.2 PG4410.2 PR4416.2 PU4403.5 PU4403.6 PU4403.7 PU4403.8
BT+_R: PG4404.2 PG4409.2 PL4401.2 PR4416.1
BT_ACT: R5806.1 WLAN1.5
BUFRST#: GPU1.D11 R7628.2
CAM1_MIC_GND: CCD1.5 R5207.1
CAMERA_PWR_EN: CPU1.AM4 TP2002.1
CAP_LED: KB1.4 KB2.4 R6201.2
CAP_LED#: KBC24.109 R6202.1
CAP_LED_Q: Q6201.C R6201.1
CAP_LED_R#: Q6201.B R6202.2
CARD_PWR_EN: CPU1.AL2 RN1809.8(B)
CARD_WLAN_OUT#: TP5804.1 WLAN1.44
CARD_WPAN_OUT#: TP5803.1 WLAN1.46
CBN: C2703.1 HDA27.35
CBP: C2703.2 HDA27.37
CEDAR/JANUS_ID: CPU1.AC1 R1510.2 R1511.1
CFG0: CPU1.AC60 TP9626.1
CFG1: CPU1.AC62 TP9627.1
CFG2: CPU1.AC63 TP9620.1
CFG3: CPU1.AA63 R604.1 TP9622.1
CFG4: CPU1.AA60 R605.1 TP9630.1
CFG5: CPU1.Y62 TP9631.1
CFG6: CPU1.Y61 TP9629.1
CFG7: CPU1.Y60 TP9628.1
CFG8: CPU1.V62 TP9633.1
CFG9: CPU1.V61 TP9632.1
CFG10: CPU1.V60 TP9637.1
CFG11: CPU1.U60 TP9639.1
CFG12: CPU1.T63 TP9640.1
CFG13: CPU1.T62 TP9643.1
CFG14: CPU1.T61 TP9642.1
CFG15: CPU1.T60 TP9641.1
CFG16: CPU1.AA62 TP9635.1
CFG17: CPU1.AA61 TP9634.1
CFG18: CPU1.U63 TP9636.1
CFG19: CPU1.U62 TP9638.1
CFG_RCOMP: CPU1.V63 R601.2
CHARGER_SRC: EC4401.1 EC4402.1 PC4406.1 PC4408.1 PC4409.1 PC4426.1 PG4412.2 PG4413.2 PG4414.2 PG4415.2 PU4405.5 PU4405.6 PU4405.7 PU4405.8
CHG_AGND: PC4010.2 PC4403.2 PC4404.2 PC4412.2 PC4420.2 PC4422.2 PC4423.2 PG4411.1 PQ4407.1 PQ4407.4 PR4413.2 PR4423.2 PR4424.2 PR4431.2 PU4404.21
CHG_AMBER_LED#: KBC24.16 R6104.1
CHG_AMBER_LED_R#: Q6104.B R6104.2
CLK_DP2VGA: R1813.2 R5506.1
CLK_LAN_REQ4#_R: LOM30.12 Q3002.E R3004.2 R3005.2
CLK_LAN_REQ#_EN: Q3002.B R3003.2
CLK_PCI_KBC: EC1801.1 KBC24.2 R1805.2
CLK_PCI_KBC_R: CPU1.AP15 R1805.1
CLK_PCI_LPC: DB1.9 EC1802.1 R1804.2
CLK_PCI_LPC_R: CPU1.AN15 R1804.1 R1813.1
CLK_PCIE_LAN_N4: CPU1.B38 LOM30.16
CLK_PCIE_LAN_P4: CPU1.C37 LOM30.15
CLK_PCIE_LAN_REQ4#: CPU1.N1 Q3002.C R3005.1 RN2011.8(B)
CLK_PCIE_REQ#: CPU1.T2 CPU1.U2 CPU1.Y5 RN1801.6(B)
CLK_PCIE_VGA: CPU1.B39 GPU1.AE8
CLK_PCIE_VGA#: CPU1.A39 GPU1.AD8
CLK_PCIE_WLAN_N3: CPU1.C41 WLAN1.11
CLK_PCIE_WLAN_P3: CPU1.B42 WLAN1.13
CLK_PCIE_WLAN_REQ3#: CPU1.AD1 RN1505.6(B) WLAN1.7
CODEC_BITCLK_R: HDA27.6 R2720.2
CODEC_SDOUT_R: HDA27.5 R2719.2
COLOR_ENGINE: CPU1.E3 TP2003.1
COMBO-GPI: HDA27.48 TP2702.1
CPU_RXN_C_DGPU_TXN0: C7302.1 CPU1.F10
CPU_RXN_C_DGPU_TXN1: C7304.1 CPU1.F8
CPU_RXN_C_DGPU_TXN2: C7306.1 CPU1.H10
CPU_RXN_C_DGPU_TXN3: C7308.1 CPU1.E6
CPU_RXP_C_DGPU_TXP0: C7301.1 CPU1.E10
CPU_RXP_C_DGPU_TXP1: C7303.1 CPU1.E8
CPU_RXP_C_DGPU_TXP2: C7305.1 CPU1.G10
CPU_RXP_C_DGPU_TXP3: C7307.1 CPU1.F6
CPVEE: C2704.2 HDA27.34
CRT_B: C5518.1 CRT1.3 L5502.2
CRT_DDCCLK_CON: C5511.1 CRT1.15 RN5501.2(A) U5502.4
CRT_DDCDATA_CON: C5515.1 CRT1.12 RN5501.1(A) U5502.6
CRT_G: C5510.1 CRT1.2 L5501.2
CRT_HSYNC_CON: C5513.1 CRT1.13 R5511.2 RN5502.4(B)
CRT_PCH_HPD: CPU1.C8 R5510.1 U5502.1
CRT_R: C5514.1 CRT1.1 L5503.2
CRT_VSYNC_CON: C5507.1 CRT1.14 R5507.2 RN5502.3(B)
DBC_EN: CPU1.K3 R5224.2 RN2011.6(B)
DBC_EN_R: LCD1.8 R5224.1
DC_IN_D: PQ4402.3 PR4404.2
DC_TEST_A3_B3: CPU1.A3 CPU1.B3
DC_TEST_A61_B61: CPU1.A61 CPU1.B61
DC_TEST_AY2_AW2: CPU1.AW2 CPU1.AY2
DC_TEST_AY3_AW3: CPU1.AW3 CPU1.AY3
DC_TEST_AY61_AW61: CPU1.AW61 CPU1.AY61
DC_TEST_AY62_AW62: CPU1.AW62 CPU1.AY62
DC_TEST_B62_B63: CPU1.B62 CPU1.B63
DC_TEST_C1_C2: CPU1.C1 CPU1.C2
DCBATOUT: EC9701.1 EC9702.1 EC9703.1 EC9704.1 EC9705.1 EC9706.1 EC9707.1 EC9708.1 EC9709.1 EC9710.1 EC9711.1 EC9712.1 EC9713.1 EC9714.1 EC9715.1 EC9716.1 EC9717.1 EC9740.1 EC9741.2 EC9742.1 EC9747.2 EC9748.1 EC9749.2 F5201.1 PC4431.1 PC4519.1 PC4531.1 PG4403.1 PG4412.1 PG4413.1 PG4414.1 PG4415.1 PG4518.2 PG4520.2 PG4521.2 PG4524.2 PG4525.2 PG4531.2 PG4534.2 PG4536.2 PG4542.2 PG4543.2 PG4703.1 PG4704.1 PG4705.1 PG4706.1 PG4707.1 PG4708.1 PG4827.2 PG4834.2 PG4837.2 PG4838.2 PG4903.2 PG4904.2 PG4905.2 PG4906.2 PG5101.1 PG5102.1 PG5103.1 PG8201.1 PG8202.1 PG8203.1 PG8204.1 PG8205.1 PG8206.1 PG8207.1 PG8208.1 PG8209.1 PG8210.1 PG8211.1 PG8212.1 PR4402.2 PR4468.1 PR8202.1 PR8312.2 PT4702.1 PU4403.1 PU4403.2 PU4403.3 PU4407.3 PU4503.12
DCBATOUT_LCD: AFTP5204.1 C5202.1 C5205.2 F5201.2 LCD1.1 LCD1.2
DCBATOUT_R: PG4404.1 PR4448.1
DDPB_CTRLCLK: CPU1.B9 RN1501.4(B)
DDPB_CTRLDATA: CPU1.C9 RN1501.3(B)
DDPC_CTRLDATA: CPU1.D11 TP1502.1
DDR3_DRAMRST#: C1217.1 DM1.30 R404.2
DDR_PG_CTRL: CPU1.AV61 R1205.1
DDR_PG_CTRL_R: Q1201.S R1205.2
DDR_VREF_S3: PR4911.2 R3704.1 R3710.1
DDR_VTT_PG_CTRL: Q1201.D Q1202.G R1204.1 R1208.2 R4909.2
DDR_VTT_PG_CTRL_R: PU4901.17 R4909.1 R4910.1
DDR_WR_VREF01: C3702.1 CPU1.AR51 R3702.1
DEBUG: R5807.2 WLAN1.49
DGPU_HOLD_RST#: CPU1.L3 EC1502.1 R7304.1 RN1503.4(B) U7301.1
DGPU_PWR_EN: CPU1.L1 PQ8305.2 PR8260.1 RN1503.3(B) U8301.5
DGPU_PWR_EN#: PQ8305.5 PQ8305.6 PQ8307.G PR8313.2
DGPU_PWROK: CPU1.R5 D8301.2 EC1501.1 PR8203.2 PU8201.13 R1509.2 R2437.1 R8312.1 R8313.1
DGPU_PWROK_KBC: KBC24.63 R2437.2
DGPU_RXN_C_CPU_TXN0: C1606.1 GPU1.AG7
DGPU_RXN_C_CPU_TXN1: C1608.1 GPU1.AE7
DGPU_RXN_C_CPU_TXN2: C1610.1 GPU1.AF9
DGPU_RXN_C_CPU_TXN3: C1612.1 GPU1.AG10
DGPU_RXN_CPU_TXN0: C1606.2 CPU1.C23
DGPU_RXN_CPU_TXN1: C1608.2 CPU1.B23
DGPU_RXN_CPU_TXN2: C1610.2 CPU1.B21
DGPU_RXN_CPU_TXN3: C1612.2 CPU1.B22
DGPU_RXP_C_CPU_TXP0: C1605.1 GPU1.AG6
DGPU_RXP_C_CPU_TXP1: C1607.1 GPU1.AF7
DGPU_RXP_C_CPU_TXP2: C1609.1 GPU1.AE9
DGPU_RXP_C_CPU_TXP3: C1611.1 GPU1.AG9
DGPU_RXP_CPU_TXP0: C1605.2 CPU1.C22
DGPU_RXP_CPU_TXP1: C1607.2 CPU1.A23
DGPU_RXP_CPU_TXP2: C1609.2 CPU1.C21
DGPU_RXP_CPU_TXP3: C1611.2 CPU1.A21
DGPU_TXN_CPU_RXN0: C7302.2 GPU1.AB9
DGPU_TXN_CPU_RXN1: C7304.2 GPU1.AC10
DGPU_TXN_CPU_RXN2: C7306.2 GPU1.AC11
DGPU_TXN_CPU_RXN3: C7308.2 GPU1.AB12
DGPU_TXP_CPU_RXP0: C7301.2 GPU1.AC9
DGPU_TXP_CPU_RXP1: C7303.2 GPU1.AB10
DGPU_TXP_CPU_RXP2: C7305.2 GPU1.AD11
DGPU_TXP_CPU_RXP3: C7307.2 GPU1.AC12
DIS_1D35V_VGA_S0: PQ8306.D PR8315.2
DMIC_CLK: C2723.2 EC5206.1 R2716.1 RN5202.4(B) RN5204.3(B)
DMIC_CLK_C: AFTP5222.1 CCD1.3 RN5202.1(A)
DMIC_CLK_EDP: LCD1.27 RN5204.2(A)
DMIC_CLK_R: HDA27.3 R2716.2
DMIC_DATA: EC5205.1 R2714.1 RN5202.3(B) RN5204.4(B)
DMIC_DATA_C: AFTP5228.1 CCD1.4 RN5202.2(A)
DMIC_DATA_EDP: LCD1.28 RN5204.1(A)
DMIC_DATA_R: EC2701.1 HDA27.2 R2714.2
DP_CRT_B: C5509.1 L5502.1 R5501.1 U5502.10
DP_CRT_G: C5512.1 L5501.1 R5513.1 U5502.12
DP_CRT_HSYNC_CON: R5511.1 U5501.2 U5502.8
DP_CRT_R: C5506.1 L5503.1 R5514.1 U5502.15
DP_CRT_VSYNC_CON: R5507.1 U5501.5 U5502.7
DS3_PWRCTL: R3802.2 U3801.4
DSWODVREN: CPU1.AW7 R1720.1 R1721.1
E51_RX: TP5802.1 WLAN1.17
E51_TX: R5804.2 WLAN1.19
E51_TXD: KBC24.111 R5804.1
EAPD#: HDA27.47 R2708.2
EC_AGND: C2402.1 C2403.1 C2404.2 C2405.2 C2414.1 KBC24.103 R2406.2 R2407.2 R2435.2
EC_BRIGHTNESS: D5202.2 KBC24.32
EC_SCI#: CPU1.AM2 R2408.2 RN1809.6(B)
EC_SMI#: CPU1.V1 R2409.2 RN1902.3(A)
EC_SPI_CLK_C: KBC24.92 R2420.2
EC_SPI_CS#_C: KBC24.90 R2419.2
EC_SPI_DI_C: KBC24.87 R2422.2
EC_SPI_DO_C: KBC24.86 R2423.2
EC_SWI#: CPU1.AM3 R2410.2 RN2012.8(B)
EC_VBKUP: KBC24.114 R2428.1
EC_VTT: C2401.1 KBC24.12 R2401.2
ECRST#: C2418.1 KBC24.85 Q2404.E R2418.1 R2424.2
ECSCI#_KBC: KBC24.29 R2408.1
ECSMI#_KBC: KBC24.6 R2409.1
ECSWI#_KBC: KBC24.123 R2410.1
EDP_AUX: AFTP5206.1 C5212.2 LCD1.11
EDP_AUX#: AFTP5208.1 C5209.2 LCD1.12
EDP_AUX_DN: C5209.1 CPU1.A45
EDP_AUX_DP: C5212.1 CPU1.B45
EDP_BKLT_CTRL: D5202.1 R5206.2 R5222.2
EDP_BRIGHTNESS: CPU1.A43 TP801.1
EDP_COMP: CPU1.D20 R801.2
EDP_HPD: CPU1.D6 R5233.2 RN5203.6(B)
EDP_HPD_CONN: AFTP5201.1 LCD1.9 R5233.1
EDP_SPARE: CPU1.B43 TP605.1
EDP_TX0: AFTP5210.1 C5210.2 LCD1.15
EDP_TX0#: AFTP5213.1 C5203.2 LCD1.14
EDP_TX0_DN: C5203.1 CPU1.C45
EDP_TX0_DP: C5210.1 CPU1.B46
EDP_TX1: AFTP5212.1 C5213.2 LCD1.18
EDP_TX1#: AFTP5211.1 C5211.2 LCD1.17
EDP_TX1_DN: C5211.1 CPU1.A47
EDP_TX1_DP: C5213.1 CPU1.B47
EDP_VDD_EN: CPU1.C6 D5201.1
FAN1_DAC_1: FAN261.4 KBC24.101
FAN_TACH1: EC2602.1 KBC24.31 R2415.1 R2606.1
FAN_TACH1_C: AFTP2802.1 FAN1.3 R2606.2
FAN_VCC1: AFTP2801.1 C2603.1 C2604.1 D2601.K EC2601.1 FAN1.1 FAN261.3
FB_CAL_PD_VDDQ: GPU1.D22 R7505.1
FB_CAL_PU_GND: GPU1.C24 R7507.2
FB_CAL_TERM_GND: GPU1.B25 R7506.1
FB_CLAM: GPU1.F3 R7518.1 R7519.1
FB_CLAMP_MON_S: Q7603.5 Q7603.6 R7650.1
FB_VREF: GPU1.D23 TP7503.1
FBA_CLK0N: GPU1.D25 R7810.1 VRAM1.K7 VRAM2.K7
FBA_CLK0P: GPU1.D24 R7810.2 VRAM1.J7 VRAM2.J7
FBA_CLK1N: GPU1.M22 R7914.1 VRAM3.K7 VRAM4.K7
FBA_CLK1P: GPU1.N22 R7914.2 VRAM3.J7 VRAM4.J7
FBA_CMD0: GPU1.C27 VRAM1.L2 VRAM2.L2
FBA_CMD1: GPU1.C26 TP7501.1
FBA_CMD2: GPU1.E24 R7511.1 VRAM1.K1 VRAM2.K1
FBA_CMD3: GPU1.F24 R7510.1 VRAM1.K9 VRAM2.K9
FBA_CMD4: GPU1.D27 VRAM1.T7 VRAM2.T7 VRAM3.T7 VRAM4.T7
FBA_CMD5: GPU1.D26 R7512.1 VRAM1.T2 VRAM2.T2 VRAM3.T2 VRAM4.T2
FBA_CMD6: GPU1.F25 VRAM1.R3 VRAM2.R3 VRAM3.R3 VRAM4.R3
FBA_CMD7: GPU1.F26 VRAM1.R2 VRAM2.R2 VRAM3.R2 VRAM4.R2
FBA_CMD8: GPU1.F23 VRAM1.P3 VRAM2.P3 VRAM3.P3 VRAM4.P3
FBA_CMD9: GPU1.G22 VRAM1.N3 VRAM2.N3 VRAM3.N3 VRAM4.N3
FBA_CMD10: GPU1.G23 VRAM1.P8 VRAM2.P8 VRAM3.P8 VRAM4.P8
FBA_CMD11: GPU1.G24 VRAM1.P7 VRAM2.P7 VRAM3.P7 VRAM4.P7
FBA_CMD12: GPU1.F27 VRAM1.M2 VRAM2.M2 VRAM3.M2 VRAM4.M2
FBA_CMD13: GPU1.G25 VRAM1.L3 VRAM2.L3 VRAM3.L3 VRAM4.L3
FBA_CMD14: GPU1.G27 TP7505.1
FBA_CMD15: GPU1.G26 VRAM1.K3 VRAM2.K3 VRAM3.K3 VRAM4.K3
FBA_CMD16: GPU1.M24 VRAM3.L2 VRAM4.L2
FBA_CMD17: GPU1.M23 TP7502.1
FBA_CMD18: GPU1.K24 R7508.1 VRAM3.K1 VRAM4.K1
FBA_CMD19: GPU1.K23 R7509.1 VRAM3.K9 VRAM4.K9
FBA_CMD20: GPU1.M27 VRAM1.T3 VRAM2.T3 VRAM3.T3 VRAM4.T3
FBA_CMD21: GPU1.M26 VRAM1.T8 VRAM2.T8 VRAM3.T8 VRAM4.T8
FBA_CMD22: GPU1.M25 VRAM1.R8 VRAM2.R8 VRAM3.R8 VRAM4.R8
FBA_CMD23: GPU1.K26 VRAM1.R7 VRAM2.R7 VRAM3.R7 VRAM4.R7
FBA_CMD24: GPU1.K22 VRAM1.P2 VRAM2.P2 VRAM3.P2 VRAM4.P2
FBA_CMD25: GPU1.J23 VRAM1.N2 VRAM2.N2 VRAM3.N2 VRAM4.N2
FBA_CMD26: GPU1.J25 VRAM1.M3 VRAM2.M3 VRAM3.M3 VRAM4.M3
FBA_CMD27: GPU1.J24 VRAM1.N8 VRAM2.N8 VRAM3.N8 VRAM4.N8
FBA_CMD28: GPU1.K27 VRAM1.N7 VRAM2.N7 VRAM3.N7 VRAM4.N7
FBA_CMD29: GPU1.K25 VRAM1.L7 VRAM2.L7 VRAM3.L7 VRAM4.L7
FBA_CMD30: GPU1.J27 VRAM1.J3 VRAM2.J3 VRAM3.J3 VRAM4.J3
FBA_CMD31: GPU1.J26 TP7504.1
FBA_D0: GPU1.E18 VRAM1.E3
FBA_D1: GPU1.F18 VRAM1.H3
FBA_D2: GPU1.E16 VRAM1.F2
FBA_D3: GPU1.F17 VRAM1.G2
FBA_D4: GPU1.D20 VRAM1.F7
FBA_D5: GPU1.D21 VRAM1.H8
FBA_D6: GPU1.F20 VRAM1.H7
FBA_D7: GPU1.E21 VRAM1.F8
FBA_D8: GPU1.E15 VRAM1.C8
FBA_D9: GPU1.D15 VRAM1.B8
FBA_D10: GPU1.F15 VRAM1.D7
FBA_D11: GPU1.F13 VRAM1.A7
FBA_D12: GPU1.C13 VRAM1.C2
FBA_D13: GPU1.B13 VRAM1.C3
FBA_D14: GPU1.E13 VRAM1.A3
FBA_D15: GPU1.D13 VRAM1.A2
FBA_D16: GPU1.B15 VRAM2.F8
FBA_D17: GPU1.C16 VRAM2.F7
FBA_D18: GPU1.A13 VRAM2.H7
FBA_D19: GPU1.A15 VRAM2.H8
FBA_D20: GPU1.B18 VRAM2.F2
FBA_D21: GPU1.A18 VRAM2.E3
FBA_D22: GPU1.A19 VRAM2.H3
FBA_D23: GPU1.C19 VRAM2.G2
FBA_D24: GPU1.B24 VRAM2.A2
FBA_D25: GPU1.C23 VRAM2.C3
FBA_D26: GPU1.A25 VRAM2.C2
FBA_D27: GPU1.A24 VRAM2.A3
FBA_D28: GPU1.A21 VRAM2.B8
FBA_D29: GPU1.B21 VRAM2.A7
FBA_D30: GPU1.C20 VRAM2.D7
FBA_D31: GPU1.C21 VRAM2.C8
FBA_D32: GPU1.R22 VRAM3.E3
FBA_D33: GPU1.R24 VRAM3.G2
FBA_D34: GPU1.T22 VRAM3.H3
FBA_D35: GPU1.R23 VRAM3.F2
FBA_D36: GPU1.N25 VRAM3.F8
FBA_D37: GPU1.N26 VRAM3.H7
FBA_D38: GPU1.N23 VRAM3.H8
FBA_D39: GPU1.N24 VRAM3.F7
FBA_D40: GPU1.V23 VRAM4.H3
FBA_D41: GPU1.V22 VRAM4.E3
FBA_D42: GPU1.T23 VRAM4.G2
FBA_D43: GPU1.U22 VRAM4.F2
FBA_D44: GPU1.Y24 VRAM4.H7
FBA_D45: GPU1.AA24 VRAM4.F7
FBA_D46: GPU1.Y22 VRAM4.H8
FBA_D47: GPU1.AA23 VRAM4.F8
FBA_D48: GPU1.AD27 VRAM4.B8
FBA_D49: GPU1.AB25 VRAM4.D7
FBA_D50: GPU1.AD26 VRAM4.A7
FBA_D51: GPU1.AC25 VRAM4.C8
FBA_D52: GPU1.AA27 VRAM4.A3
FBA_D53: GPU1.AA26 VRAM4.C3
FBA_D54: GPU1.W26 VRAM4.C2
FBA_D55: GPU1.Y25 VRAM4.A2
FBA_D56: GPU1.R26 VRAM3.C8
FBA_D57: GPU1.T25 VRAM3.A7
FBA_D58: GPU1.N27 VRAM3.D7
FBA_D59: GPU1.R27 VRAM3.B8
FBA_D60: GPU1.V26 VRAM3.A3
FBA_D61: GPU1.V27 VRAM3.C3
FBA_D62: GPU1.W27 VRAM3.A2
FBA_D63: GPU1.W25 VRAM3.C2
FBA_DEBUG0: GPU1.F22 R7501.1
FBA_DEBUG1: GPU1.J22 R7503.1
FBA_DQM0: GPU1.D19 VRAM1.E7
FBA_DQM1: GPU1.D14 VRAM1.D3
FBA_DQM2: GPU1.C17 VRAM2.E7
FBA_DQM3: GPU1.C22 VRAM2.D3
FBA_DQM4: GPU1.P24 VRAM3.E7
FBA_DQM5: GPU1.W24 VRAM4.E7
