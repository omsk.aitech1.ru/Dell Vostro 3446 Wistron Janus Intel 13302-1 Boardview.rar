# Allegro board Janus Intel MB_13302-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R2501  4K7R2J-2-GP  [R402H16]  146.69 38.72 180 bottom
R2502  1KR2J-1-GP  [R402H16]  49.69 5.03 90 bottom
R2504  10MR2J-L-GP  [R402H16]  51.45 5.06 270 bottom
R2601  0R2J-2-GP  [R402H16]  112.67 109.26 270 top
R2602  0R2J-2-GP  [R402H16]  169.54 22.29 180 bottom
R2603  18K7R2F-GP  [R402H16]  118.44 112.21 180 bottom
R2604  2KR2F-3-GP  [R402H16]  112.67 110.13 90 top
R2605  0R2J-2-GP  [R402H16]  37.41 95.83 90 bottom
R2606  -  [0R0402-PAD]  41.09 93.92 180 bottom
R2607  2KR2F-3-GP  [R402H16]  170.48 22.29 180 bottom
R2608  24K9R2F-L-GP  [R402H16]  107.92 62.63 270 bottom
R2609  24K9R2F-L-GP  [R402H16]  107.92 61.74 270 bottom
R2610  NTC-100K-8-GP  [NTC-603H38]  110.16 62.37 270 bottom
R2611  -  [0R0402-PAD]  166.77 22.22 0 bottom
R2612  0R2J-2-GP  [R402H16]  163.65 22.29 180 bottom
R2701  -  [0R0402-PAD]  29.64 5.91 0 bottom
R2702  0R0805-PAD-1-GP-U  [0R0805-PAD-U]  45.09 3.55 270 top
R2703  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  25.72 20.44 90 bottom
R2704  0R0805-PAD-1-GP-U  [0R0805-PAD-U]  45.09 5.45 270 top
R2705  -  [0R0402-PAD]  32.2 3.85 180 top
R2706  0R0805-PAD-1-GP-U  [0R0805-PAD-U]  37.03 19.88 90 top
R2707  20KR2F-L-GP  [R402H16]  36.68 17.21 180 top
R2708  -  [0R0402-PAD]  42.16 4.7 270 top
R2709  200KR2F-L-GP  [R402H16]  37.54 16.3 180 top
R2710  0R2J-2-GP  [R402H16]  31.37 3.85 180 top
R2711  100KR2J-1-GP  [R402H16]  30.55 13.81 90 bottom
R2712  0R2J-2-GP  [R402H16]  30.67 20.92 180 top
R2714  -  [0R0402-PAD]  41.37 7.69 270 top
R2716  0R2J-2-GP  [R402H16]  41.37 8.53 270 top
R2717  1KR2J-1-GP  [R402H16]  39.49 17.37 270 top
R2718  -  [0R0402-PAD]  42.15 12.57 270 top
R2719  -  [0R0402-PAD]  40.08 10.61 90 bottom
R2720  0R2J-2-GP  [R402H16]  41.32 10.36 270 top
R2722  100KR2J-1-GP  [R402H16]  38.35 14.65 0 bottom
R2901  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  79.37 2.68 270 top
R2902  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  79.37 4.36 270 top
R2903  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  79.37 7.59 270 top
R2904  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  79.37 6.24 270 top
R2905  100KR2J-1-GP  [R402H16]  16.91 7.76 180 bottom
R2906  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  18.08 3.34 180 top
R2907  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  22.78 2.61 90 top
R2908  10R2F-L-GP  [R402H14]  28.96 10.34 270 top
R2909  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  24.79 11.85 90 top
R2910  10R2F-L-GP  [R402H14]  25.69 10.3 180 top
R2911  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  23.19 4.49 0 top
R2912  4K7R2J-2-GP  [R402H16]  28.96 11.15 270 top
R2913  4K7R2J-2-GP  [R402H16]  26.95 12.22 270 top
R2914  10KR2J-3-GP  [R402H16]  18.49 9.95 90 bottom
R2915  470KR2J-2-GP  [R402H16]  29.85 19.88 180 bottom
R2916  -  [0R0402-PAD]  18.49 10.81 270 bottom
R2917  0R3J-0-U-GP  [R603H22]  40.97 16.92 180 top
R2918  100KR2J-1-GP  [R402H16]  42.91 17.26 180 top
R2919  10KR2J-3-GP  [R402H16]  26.12 14.89 90 top
R2920  10KR2J-3-GP  [R402H16]  25.85 18.23 180 top
R2921  1KR2J-1-GP  [R402H16]  26.74 18.1 0 top
R2922  1KR2J-1-GP  [R402H16]  26.24 16.83 270 top
R2923  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  19.28 7.94 180 bottom
R3001  0R3J-0-U-GP  [R603H22]  48.27 65 0 bottom
R3003  10KR2J-3-GP  [R402H16]  38.22 61.23 180 top
R3004  10KR2J-3-GP  [R402H16]  35.26 59.42 270 top
R3005  -  [0R0402-PAD]  33.86 60.01 0 top
R3006  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  43.7 66.86 180 bottom
R3014  1KR2J-1-GP  [R402H16]  37.57 64.64 180 top
R3015  15KR2J-1-GP  [R402H16]  38.4 64.63 0 top
R3016  -  [0R0603-PAD]  39.41 66.24 90 top
R3021  10KR2J-3-GP  [R402H16]  37.48 49.3 0 top
R3022  20KR2J-L2-GP  [R402H16]  36.59 49.3 180 top
R3023  100KR2J-1-GP  [R402H16]  37.56 44.16 90 top
R3032  2K49R2F-GP  [R402H16]  46.09 56.86 90 bottom
R3033  10KR2J-3-GP  [R402H16]  40.34 66.15 0 bottom
R3408  -  [0R0402-PAD]  24.61 28.49 270 bottom
R3409  -  [0R0402-PAD]  24.61 27.47 270 bottom
R3410  -  [0R0402-PAD]  28.09 25.65 270 bottom
R3411  -  [0R0402-PAD]  28.09 24.79 270 bottom
R3501  100KR2J-1-GP  [R402H16]  19.84 27.12 0 top
R3502  100KR2J-1-GP  [R402H16]  160.21 4.99 180 bottom
R3601  1KR2J-1-GP  [R402H16]  132.08 126.61 180 top
R3602  200KR2F-L-GP  [R402H16]  152.03 24.81 180 top
R3603  1KR2J-1-GP  [R402H16]  151.21 24.81 180 top
R3605  2K2R2J-2-GP  [R402H16]  155.4 18.45 180 top
R3606  4K7R2J-2-GP  [R402H16]  154.97 17.2 90 top
R3607  100KR2J-1-GP  [R402H16]  114.55 13.28 270 top
R3608  1KR2J-1-GP  [R402H16]  153.29 19.6 270 top
R3609  -  [0R0402-PAD]  131.82 10.64 0 top
R3610  -  [0R0402-PAD]  132.92 126.61 180 top
R3611  -  [0R0402-PAD]  131.85 127.88 90 top
R3701  1K8R2F-GP  [R402H16]  56.54 35.32 180 top
R3702  2R2F-GP  [R402H16]  57.23 37.84 0 top
R3703  1K8R2F-GP  [R402H16]  65.73 50.72 270 top
R3704  0R2J-2-GP  [R402H16]  59.69 36.55 90 top
R3706  1K8R2F-GP  [R402H16]  67.64 51.56 270 top
R3707  24D9R2F-L-GP  [R402H16]  65.73 53.28 270 top
R3708  2R2F-GP  [R402H16]  67.64 52.39 90 top
R3709  1K8R2F-GP  [R402H16]  65.31 52 180 top
R3710  0R2J-2-GP  [R402H16]  58.77 35.71 270 top
R3711  24D9R2F-L-GP  [R402H16]  55.93 38.27 270 top
R3801  0R5J-5-GP  [R805H24]  138.88 60.14 0 bottom
R3802  0R2J-2-GP  [R402H16]  133.25 58.32 0 bottom
R4622  2KR2F-3-GP  [R402H16]  121.74 118.45 0 top
R4909  -  [0R0402-PAD]  103.97 9.99 270 top
R4910  0R2J-2-GP  [R402H16]  103.96 10.81 270 top
R5201  -  [0R0402-PAD]  34.42 81.42 90 top
R5202  100KR2J-1-GP  [R402H16]  51.28 76.8 90 top
R5203  -  [0R0402-PAD]  32.18 79.86 0 top
R5204  -  [0R0402-PAD]  31.34 79.86 0 top
R5205  -  [0R0402-PAD]  38.95 81.39 0 bottom
R5206  -  [0R0402-PAD]  45.83 80.16 0 bottom
R5207  0R2J-2-GP  [R402H16]  20.52 88.21 270 bottom
R5208  10KR2J-3-GP  [R402H16]  38.05 85.79 0 bottom
R5209  0R2J-2-GP  [R402H16]  37.16 85.79 180 bottom
R5210  100R2J-2-GP  [R402H14]  36.27 85.79 0 bottom
R5211  0R5J-5-GP  [R805H24]  48.41 77.79 0 top
R5212  -  [0R0402-PAD]  35.7 81.38 0 bottom
R5222  0R2J-2-GP  [R402H16]  40.9 79.76 0 bottom
R5224  -  [0R0402-PAD]  45.35 80.09 0 top
R5229  0R3J-0-U-GP  [R603H22]  17.98 92.27 90 bottom
R5230  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  33.19 70.02 90 top
R5231  0R3J-0-U-GP  [R603H22]  33.19 71.32 90 top
R5232  0R3J-0-U-GP  [R603H22]  30.4 77.25 90 top
R5233  100R2J-2-GP  [R402H14]  46.41 76.9 0 top
R5501  75R2F-2-GP  [R402H16]  12.65 83.46 180 top
R5502  4K7R2J-2-GP  [R402H16]  16.74 75.13 180 bottom
R5503  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  12.52 86.94 0 top
R5504  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  19.5 73.98 0 bottom
R5505  12KR2F-L-GP  [R402H16]  19.73 80.89 0 bottom
R5506  0R2J-2-GP  [R402H16]  13.69 74.52 180 top
R5507  33R2J-2-GP  [R402H16]  23.95 82.75 0 bottom
R5508  4K7R2J-2-GP  [R402H16]  17.08 77.34 180 bottom
R5509  4K7R2J-2-GP  [R402H16]  17.58 75.13 180 bottom
R5510  100KR2J-4-GP  [R402H15]  19.15 82.54 90 bottom
R5511  33R2J-2-GP  [R402H16]  23.11 82.75 0 bottom
R5512  4K7R2J-2-GP  [R402H16]  16.24 77.34 180 bottom
R5513  75R2F-2-GP  [R402H16]  12.62 80.43 0 top
R5514  75R2F-2-GP  [R402H16]  12.66 77.67 0 top
R5515  4K7R2J-2-GP  [R402H16]  18.41 75.13 180 bottom
R5516  4K7R2J-2-GP  [R402H16]  17.91 77.34 180 bottom
R5602  -  [0R0402-PAD]  194 85.54 90 bottom
R5603  0R5J-5-GP  [R805H24]  196.2 72.65 90 top
R5604  10KR2J-3-GP  [R402H16]  196.85 75.61 180 bottom
R5607  100KR2J-1-GP  [R402H16]  191.54 76.61 0 bottom
R5801  0R2J-2-GP  [R402H16]  190.65 26.58 270 top
R5802  -  [0R0402-PAD]  171.94 16.85 90 bottom
R5803  -  [0R0402-PAD]  171.94 15.97 90 bottom
R5804  0R2J-2-GP  [R402H16]  168.19 20.04 270 top
R5805  -  [0R0402-PAD]  189.8 27.41 90 top
R5806  0R2J-2-GP  [R402H16]  189.39 26.16 180 top
R5807  0R2J-2-GP  [R402H16]  191.1 25.29 0 top
R6101  330R2J-3-GP  [R402H16]  180.06 18.48 270 top
R6102  100R2J-2-GP  [R402H14]  100.31 129.95 270 top
R6103  499R2F-2-GP  [R402H16]  180.06 17.65 270 top
R6104  -  [0R0402-PAD]  176.93 19.8 0 top
R6105  -  [0R0402-PAD]  171.14 19.58 270 top
R6201  1KR2J-1-GP  [R402H16]  193.75 87.57 180 top
R6202  -  [0R0402-PAD]  193.75 85.79 180 top
R6203  10KR2J-3-GP  [R402H16]  129.61 98.87 180 top
R6204  0R2J-2-GP  [R402H16]  133.37 96.92 90 bottom
R6205  0R3J-0-U-GP  [R603H22]  137.77 78.07 270 bottom
R6206  51KR2J-1-GP  [R402H16]  139.42 78.33 0 bottom
R6207  100KR2J-1-GP  [R402H16]  140.31 78.33 0 bottom
R6208  100KR2J-1-GP  [R402H16]  137.31 69.54 90 bottom
R6209  0R2J-2-GP  [R402H16]  140.28 88.59 270 bottom
R6210  0R2J-2-GP  [R402H16]  131.65 96.11 90 bottom
R6211  4K7R2J-2-GP  [R402H16]  136.78 96.03 270 top
R6212  0R2J-2-GP  [R402H16]  140.41 94.81 270 bottom
R6213  0R2J-2-GP  [R402H16]  140.79 96.08 180 bottom
R6214  1KR2J-1-GP  [R402H16]  139.9 86.43 0 bottom
R6215  10KR2J-3-GP  [R402H16]  129.99 100.14 90 top
R6216  0R2J-2-GP  [R402H16]  122.28 115.24 90 bottom
R6217  0R2J-2-GP  [R402H16]  121.86 113.98 0 bottom
R6401  100KR2J-1-GP  [R402H16]  11.37 74.73 90 top
R6501  0R2J-2-GP  [R402H16]  160.23 13.55 0 top
R6502  0R2J-2-GP  [R402H16]  129.99 86.31 90 bottom
R7301  2K49R2F-GP  [R402H16]  152.25 126.08 90 bottom
R7302  10KR2F-2-GP  [R402H16]  153.36 113.65 90 bottom
R7303  10KR2J-3-GP  [R402H16]  161.17 109.13 90 top
R7304  0R2J-2-GP  [R402H16]  155.47 100.83 180 top
R7305  0R2J-2-GP  [R402H16]  155.02 99.1 90 top
R7306  100KR2F-L1-GP  [R402H16]  154.63 101.43 180 top
R7307  200R2F-L-GP  [R402H16]  153.92 121.4 180 bottom
R7308  0R2J-2-GP  [R402H16]  152.42 105.07 90 top
R7312  10KR2J-3-GP  [R402H16]  152.42 103.19 270 top
R7313  0R2J-2-GP  [R402H16]  182.78 104.03 0 bottom
R7501  60D4R2F-GP  [R402H16]  174.14 121.35 0 top
R7503  60D4R2F-GP  [R402H16]  173.2 120.57 0 top
R7505  40D2R2F-GP  [R402H16]  180.52 121.77 90 top
R7506  51D1R2F-GP  [R402H16]  181.07 129.58 180 top
R7507  42D2R2F-GP  [R402H16]  180.52 122.66 270 top
R7508  10KR2F-2-GP  [R402H16]  158.75 151.05 0 bottom
R7509  10KR2F-2-GP  [R402H16]  159.56 151.05 0 bottom
R7510  10KR2F-2-GP  [R402H16]  177.03 151.18 0 bottom
R7511  10KR2F-2-GP  [R402H16]  177.87 151.18 0 bottom
R7512  10KR2F-2-GP  [R402H16]  177.49 127.03 0 top
R7518  10KR2J-3-GP  [R402H16]  189.93 108.12 270 bottom
R7519  0R2J-2-GP  [R402H16]  189.92 108.94 270 bottom
R7601  10KR2J-3-GP  [R402H16]  178.91 111.1 270 top
R7602  49K9R2F-L-GP  [R402H16]  178.21 113.86 180 top
R7603  1MR2J-1-GP  [R402H16]  182.27 111.88 180 bottom
R7604  0R2J-2-GP  [R402H16]  182.28 110.17 0 bottom
R7605  100KR2J-1-GP  [R402H16]  175.38 103.37 270 top
R7606  10KR2J-3-GP  [R402H16]  176.2 107.94 270 top
R7607  40K2R2F-GP  [R402H16]  173.84 108.48 90 top
R7608  10KR2F-2-GP  [R402H16]  187.56 116.12 180 bottom
R7609  10KR2J-3-GP  [R402H16]  170.76 101.41 90 bottom
R7610  100KR2J-1-GP  [R402H16]  184.19 102.31 270 bottom
R7611  4K99R2F-L-GP  [R402H16]  188.85 119.73 0 bottom
R7612  10KR2J-3-GP  [R402H16]  188.11 104.65 180 bottom
R7613  10KR2J-3-GP  [R402H16]  183.66 104.05 180 bottom
R7614  10KR2F-2-GP  [R402H16]  186.74 116.12 0 bottom
R7615  10KR2J-3-GP  [R402H16]  187.04 114.02 270 bottom
R7616  4K99R2F-L-GP  [R402H16]  185.26 116.11 0 bottom
R7617  49K9R2F-L-GP  [R402H16]  179.03 113.77 0 top
R7618  10KR2F-2-GP  [R402H16]  186.47 117.88 0 bottom
R7619  10KR2F-2-GP  [R402H16]  187.3 117.88 180 bottom
R7620  10KR2F-2-GP  [R402H16]  187.14 119.7 180 bottom
R7621  10KR2J-3-GP  [R402H16]  175.09 101.43 90 bottom
R7622  10KR2J-3-GP  [R402H16]  172.54 101.41 90 bottom
R7623  0R2J-2-GP  [R402H16]  190.36 110.2 0 bottom
R7624  -  [0R0402-PAD]  194.01 116.2 0 bottom
R7625  10KR2J-3-GP  [R402H16]  175.09 100.61 270 bottom
R7626  10KR2J-3-GP  [R402H16]  174.5 111.65 270 top
R7627  10KR2J-3-GP  [R402H16]  184.14 106.86 180 bottom
R7628  10KR2J-3-GP  [R402H16]  177.39 113.86 0 top
R7629  0R2J-2-GP  [R402H16]  181.96 104.31 180 bottom
R7630  0R2J-2-GP  [R402H16]  174.81 105.03 270 top
R7631  10KR2J-3-GP  [R402H16]  174.81 104.21 270 top
R7632  10KR2J-3-GP  [R402H16]  176.77 101.43 270 bottom
R7633  10KR2J-3-GP  [R402H16]  182.55 100.53 90 bottom
R7634  10KR2J-3-GP  [R402H16]  176.89 100.61 90 bottom
R7635  10KR2J-3-GP  [R402H16]  173.83 101 0 bottom
R7636  0R2J-2-GP  [R402H16]  182.24 98.24 180 bottom
R7637  10KR2J-3-GP  [R402H16]  176.2 108.76 270 top
R7638  15KR2F-GP  [R402H16]  188.93 117.88 180 bottom
R7639  20KR2F-L-GP  [R402H16]  188.11 117.88 180 bottom
R7640  20KR2F-L-GP  [R402H16]  185.63 117.88 0 bottom
R7641  24K9R2F-L-GP  [R402H16]  183.97 117.87 0 bottom
R7642  30K1R2F-L-GP  [R402H16]  184.8 117.87 0 bottom
R7643  10KR2J-3-GP  [R402H16]  181.82 106.01 0 bottom
R7644  10KR2J-3-GP  [R402H16]  185.7 97.81 90 bottom
R7645  10KR2J-3-GP  [R402H16]  186.51 102.3 270 bottom
R7646  49K9R2F-L-GP  [R402H16]  176.01 99.78 270 bottom
R7647  10KR2J-3-GP  [R402H16]  185 106.85 180 bottom
R7648  10KR2J-3-GP  [R402H16]  187.42 97.81 270 bottom
R7649  10KR2J-3-GP  [R402H16]  183.82 100.96 180 bottom
R7650  10KR2J-3-GP  [R402H16]  194.99 108.53 180 bottom
R7651  4K99R2F-L-GP  [R402H16]  187.98 119.73 180 bottom
R7652  0R2J-2-GP  [R402H16]  182.5 102.79 90 bottom
R7653  0R2J-2-GP  [R402H16]  189.38 104.21 270 bottom
R7806  1K33R2F-GP  [R402H16]  173.21 150.73 270 bottom
R7807  1K33R2F-GP  [R402H16]  178.74 151.2 0 bottom
R7808  243R2F-2-GP  [R402H16]  175.99 135.74 90 top
R7809  243R2F-2-GP  [R402H16]  176.21 151.18 180 bottom
R7810  162R2F-GP  [R402H16]  179.22 150.69 90 top
R7903  1K33R2F-GP  [R402H16]  153.16 150.7 270 bottom
R7904  1K33R2F-GP  [R402H16]  155.32 151.11 0 bottom
R7912  243R2F-2-GP  [R402H16]  158.88 135.78 270 top
R7913  243R2F-2-GP  [R402H16]  160.42 151.07 180 bottom
R7914  162R2F-GP  [R402H16]  156.72 151.44 90 bottom
R8301  100KR2J-1-GP  [R402H16]  194.23 96.66 0 bottom
R8302  10KR2J-3-GP  [R402H16]  189.35 97.22 270 bottom
R8303  0R2J-2-GP  [R402H16]  194.24 99.06 0 bottom
R8304  0R5J-5-GP  [R805H24]  179.43 100.32 0 bottom
R8305  1MR2J-1-GP  [R402H16]  183.46 50.11 0 bottom
R8312  0R2J-2-GP  [R402H16]  179.22 48.31 180 bottom
R8313  0R2J-2-GP  [R402H16]  178.37 48.31 180 bottom
R8314  750KR2J-GP  [R402H16]  178.9 52.21 270 bottom
R8315  0R2J-2-GP  [R402H16]  183.1 98.26 180 bottom
R9601  1KR2J-1-GP  [R402H16]  78.18 97.92 270 top
R9602  0R2J-2-GP  [R402H16]  130.02 83.57 270 bottom
R9603  0R2J-2-GP  [R402H16]  130.99 82.31 0 bottom
R9604  0R2J-2-GP  [R402H16]  72.03 87.52 270 bottom
R9605  0R2J-2-GP  [R402H16]  130.83 92.32 90 bottom
RJ45  RJ45-8P-165-GP  [C100HR-10805-L]  7.88 62.7 90 bottom
RN401  SRN51J-1-GP  [ARES8-CN24H22]  70.14 89.52 270 bottom
RN1501  SRN2K2J-1-GP  [ARES2H16]  117.17 98.49 0 bottom
RN1503  SRN10KJ-5-GP  [ARES2H18]  134.92 94.81 270 bottom
RN1505  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  127.53 92.8 270 bottom
RN1601  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  132.66 68.97 270 bottom
RN1701  SRN10KJ-5-GP  [ARES2H18]  133.75 85.08 270 bottom
RN1702  SRN0J-6-GP  [SMD-ARES4H20]  132.15 61.54 180 bottom
RN1703  SRN10KJ-5-GP  [ARES2H18]  122.14 59.46 180 bottom
RN1801  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  127.53 89.88 270 bottom
RN1802  SRN1KJ-7-GP  [SMD-ARES4H18]  123.47 85.34 180 top
RN1803  SRN10KJ-5-GP  [ARES2H18]  96.72 98.29 0 bottom
RN1804  SRN10KJ-5-GP  [ARES2H18]  117.04 64.83 0 top
RN1806  SRN0J-7-GP-U  [ARES8-CN24H22]  112.4 67.35 0 bottom
RN1807  SRN2K2J-4-GP  [ARES8-CN24-UH20]  132.78 77.24 270 bottom
RN1809  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  132.93 80.71 270 bottom
RN1810  SRN10KJ-5-GP  [ARES2H18]  129.87 75.7 180 bottom
RN1811  SRN2K2J-1-GP  [ARES2H16]  132.92 74.49 270 bottom
RN1901  SRN20KJ-1-GP  [SMD-ARES4H20]  119.07 62.74 0 top
RN1902  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  123.19 91.05 0 top
RN2002  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  123.64 93.54 90 top
RN2006  SRN10KJ-5-GP  [ARES2H18]  133.18 87.13 270 bottom
RN2007  SRN10KJ-5-GP  [ARES2H18]  122.64 94.43 180 bottom
RN2008  SRN10KJ-5-GP  [ARES2H18]  126.32 97.1 180 bottom
RN2011  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  119.71 93.81 90 top
RN2012  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  132.94 71.79 270 bottom
RN2401  SRN4K7J-8-GP  [SMD-ARES4H18]  156.34 38.98 180 top
RN2501  SRN4K7J-8-GP  [SMD-ARES4H18]  152.06 36.59 0 bottom
RN2602  SRN2K2J-1-GP  [ARES2H16]  125.98 60.35 0 top
RN2701  SRN0J-6-GP  [SMD-ARES4H20]  40.37 23.76 180 top
RN2901  SRN2K2J-1-GP  [ARES2H16]  35.23 17.26 180 top
RN3001  SRN10KJ-5-GP  [ARES2H18]  31.49 67.03 0 top
RN3101  SRN75J-1-GP  [ARES8-CN24H22]  22.68 46.98 180 top
RN4301  SRN100J-4-GP  [ARES8-CN24H20]  131.29 149.22 0 top
RN5201  SRN100J-4-GP  [ARES8-CN24H20]  38.76 78.66 90 bottom
RN5202  SRN33J-5-GP-U  [SMD-ARES4H18]  28.09 85.8 90 bottom
RN5203  SRN100KJ-5-GP  [ARES8-CN24H20]  45.87 74.21 0 top
RN5204  SRN33J-5-GP-U  [SMD-ARES4H18]  32.41 85.78 270 bottom
RN5205  SRN0J-6-GP  [SMD-ARES4H20]  36.35 71.61 0 bottom
RN5206  SRN0J-6-GP  [SMD-ARES4H20]  36.33 71.63 180 top
RN5501  SRN2K2J-1-GP  [ARES2H16]  12.44 89.76 90 bottom
RN5502  SRN0J-6-GP  [SMD-ARES4H20]  22.98 85.13 0 bottom
RN6201  SRN10KJ-5-GP  [ARES2H18]  134.28 74.07 0 top
RN6202  SRN33J-5-GP-U  [SMD-ARES4H18]  134.54 78.07 0 top
RN6203  SRN33J-5-GP-U  [SMD-ARES4H18]  129.23 97.6 180 bottom
RN6204  SRN10KJ-5-GP  [ARES2H18]  135.86 99.38 270 bottom
RN6501  SRN0J-7-GP-U  [ARES8-CN24H22]  162.1 13.7 180 top
RN7401  SRN10KJ-5-GP  [ARES2H18]  165.68 106.17 0 top
RN7402  SRN10KJ-5-GP  [ARES2H18]  163.65 106.17 0 top
RN7403  SRN10KJ-5-GP  [ARES2H18]  170.81 104.26 0 top
RN7404  SRN10KJ-5-GP  [ARES2H18]  167.71 106.17 0 top
RN7601  SRN4K7J-8-GP  [SMD-ARES4H18]  183.36 114.27 270 top
RN7602  SRN10KJ-5-GP  [ARES2H18]  152.62 106.49 270 top
RN7603  SRN2K2J-1-GP  [ARES2H16]  185.38 110.24 90 top
RN7604  SRN2K2J-1-GP  [ARES2H16]  185.38 112.25 90 top
RN7605  SRN2K2J-1-GP  [ARES2H16]  184.14 116.28 90 top
RN9601  SRN0J-6-GP  [SMD-ARES4H20]  129.51 79.56 270 bottom
RTC1  BAT-060003HA002M213ZL-GP-U1  [060003HA002M213ZL-U2]  60.75 12.35 180 top
S1  STF237R117H83-1-GP  [STF237R117H83]  200.02 96.03 180 bottom
S2  STF237R117H83-1-GP  [STF237R117H83]  141.32 131.36 180 bottom
SKT25  SKT-G6179HT0321-001-GP  [G6179HT0321-001]  149.3 44.75 270 bottom
SPI25  W25Q64FVSSIQ-GP  [SOIC8-1H86]  149.3 44.77 90 bottom
SPK1  ACES-CON4-29-GP  [50224-0040N-001]  86.55 2.4 0 top
SPR2  SPRING-102-GP  [SPR5930H154]  49.9 40.71 0 top
SPR3  SPRING-102-GP  [SPR5930H154]  149.47 103.43 270 top
SPR4  SPRING-43-GP-U  [SPR4527H308]  125 51.9 180 bottom
SPR5  SPRING-63-GP  [SPR5630H142]  56.9 77.7 0 bottom
SW1  ETY-CON4-34-GP  [6916K-Q04M-00L]  94.9 135.7 270 top
TC1201  ST330U2VDM-4-GP  [CT7343H79]  67 35.63 270 top
TC3501  SC100U6D3V6MX-GP  [C1206H71]  19.17 30.29 180 top
TC3502  SC100U6D3V6MX-GP  [C1206H71]  24.62 41.24 90 top
TC6301  SC100U6D3V6MX-GP  [C1206H71]  182.22 5.86 180 bottom
THM26  NCT7718W-GP  [MSOP8-1H44]  118.18 110.15 270 top
TP402  TPAD14-OP-GP  [TPAD14-OP]  76.97 87.75 180 bottom
TP403  TPAD14-OP-GP  [TPAD14-OP]  76.96 99.74 180 bottom
TP501  TPAD14-OP-GP  [TPAD14-OP]  99.15 75.6 0 top
TP601  TPAD14-OP-GP  [TPAD14-OP]  75.61 69.38 180 bottom
TP602  TPAD14-OP-GP  [TPAD14-OP]  75.61 70.63 180 bottom
TP603  TPAD14-OP-GP  [TPAD14-OP]  79.93 92.17 0 top
TP604  TPAD14-OP-GP  [TPAD14-OP]  80.86 93 0 top
TP605  TPAD14-OP-GP  [TPAD14-OP]  92.28 95.42 0 top
TP606  TPAD14-OP-GP  [TPAD14-OP]  87.48 94.71 0 top
TP607  TPAD14-OP-GP  [TPAD14-OP]  88.57 93.54 0 top
TP608  TPAD14-OP-GP  [TPAD14-OP]  80.26 87.62 0 top
TP619  TPAD14-OP-GP  [TPAD14-OP]  106.22 85.82 0 top
TP620  TPAD14-OP-GP  [TPAD14-OP]  104.33 86.31 0 top
TP701  TPAD14-OP-GP  [TPAD14-OP]  82.88 97.03 180 bottom
TP702  TPAD14-OP-GP  [TPAD14-OP]  84.02 85.69 0 top
TP703  TPAD14-OP-GP  [TPAD14-OP]  83.13 84.7 0 top
TP704  TPAD14-OP-GP  [TPAD14-OP]  83.92 86.94 0 top
TP705  TPAD14-OP-GP  [TPAD14-OP]  82.23 85.68 0 top
TP801  TPAD14-OP-GP  [TPAD14-OP]  93.67 94.56 0 top
TP1501  TPAD14-OP-GP  [TPAD14-OP]  117.29 80.71 0 top
TP1502  TPAD14-OP-GP  [TPAD14-OP]  112.8 91.99 0 top
TP1601  TPAD14-OP-GP  [TPAD14-OP]  113.1 73.78 0 top
TP1602  TPAD14-OP-GP  [TPAD14-OP]  114.12 73.02 0 top
TP1702  TPAD14-OP-GP  [TPAD14-OP]  118.41 78.89 0 top
TP1703  TPAD14-OP-GP  [TPAD14-OP]  117.29 74.81 0 top
TP1704  TPAD14-OP-GP  [TPAD14-OP]  116.91 77.6 0 top
TP1705  TPAD14-OP-GP  [TPAD14-OP]  114.91 76.47 0 top
TP1706  TPAD14-OP-GP  [TPAD14-OP]  124.61 77.07 180 bottom
TP1707  TPAD14-OP-GP  [TPAD14-OP]  114.81 78.81 0 top
TP1801  TPAD14-OP-GP  [TPAD14-OP]  122.19 79.06 180 bottom
TP1802  TPAD14-OP-GP  [TPAD14-OP]  123.35 78.68 180 bottom
TP1803  TPAD14-OP-GP  [TPAD14-OP]  123.39 77.41 180 bottom
TP1901  TPAD14-OP-GP  [TPAD14-OP]  76.91 70.81 180 bottom
TP1902  TPAD14-OP-GP  [TPAD14-OP]  114.89 67.08 180 bottom
TP2001  TPAD14-OP-GP  [TPAD14-OP]  119.33 86.66 0 top
TP2002  TPAD14-OP-GP  [TPAD14-OP]  132.66 88.71 180 bottom
TP2003  TPAD14-OP-GP  [TPAD14-OP]  117.33 89.87 0 top
TP2101  TPAD14-OP-GP  [TPAD14-OP]  107.58 85.45 0 top
TP2102  TPAD14-OP-GP  [TPAD14-OP]  110.15 84.7 0 top
TP2103  TPAD14-OP-GP  [TPAD14-OP]  108.47 87.96 0 top
TP2104  TPAD14-OP-GP  [TPAD14-OP]  107.25 88.09 0 top
TP2105  TPAD14-OP-GP  [TPAD14-OP]  111.81 82.17 0 top
TP2106  TPAD14-OP-GP  [TPAD14-OP]  114.83 80.73 0 top
TP2107  TPAD14-OP-GP  [TPAD14-OP]  110.98 88.19 0 top
TP2108  TPAD14-OP-GP  [TPAD14-OP]  110.85 77.46 0 top
TP2109  TPAD14-OP-GP  [TPAD14-OP]  113.88 82.14 0 top
TP2201  TPAD14-OP-GP  [TPAD14-OP]  77.83 66.95 180 bottom
TP2202  TPAD14-OP-GP  [TPAD14-OP]  120.6 97.1 180 bottom
TP2203  TPAD14-OP-GP  [TPAD14-OP]  78.1 97.09 180 bottom
TP2204  TPAD14-OP-GP  [TPAD14-OP]  122.18 96.7 180 bottom
TP2205  TPAD14-OP-GP  [TPAD14-OP]  80.21 94.05 0 top
TP2206  TPAD14-OP-GP  [TPAD14-OP]  122.24 69.73 180 bottom
TP2207  TPAD14-OP-GP  [TPAD14-OP]  123.47 68.78 180 bottom
TP2208  TPAD14-OP-GP  [TPAD14-OP]  76.86 69.46 180 bottom
TP2702  TPAD14-OP-GP  [TPAD14-OP]  39.03 6.08 270 top
TP3001  TPAD14-OP-GP  [TPAD14-OP]  48.63 63.15 90 bottom
TP3002  TPAD14-OP-GP  [TPAD14-OP]  49.79 62.58 270 bottom
TP3003  TPAD14-OP-GP  [TPAD14-OP]  44.05 61.85 270 bottom
TP5101  TPAD14-OP-GP  [TPAD14-OP]  160.35 60.65 90 top
TP5801  TPAD14-OP-GP  [TPAD14-OP]  191.45 44.29 180 bottom
TP5802  TPAD14-OP-GP  [TPAD14-OP]  191.14 32.9 180 bottom
TP5803  TPAD14-OP-GP  [TPAD14-OP]  178.46 20.57 180 bottom
TP5804  TPAD14-OP-GP  [TPAD14-OP]  178.43 21.81 180 bottom
TP7501  TPAD14-OP-GP  [TPAD14-OP]  179.03 128.69 0 top
TP7502  TPAD14-OP-GP  [TPAD14-OP]  170.35 122.88 0 top
TP7503  TPAD14-OP-GP  [TPAD14-OP]  176.08 122.84 0 top
TP7504  TPAD14-OP-GP  [TPAD14-OP]  172.73 126.27 0 top
TP7505  TPAD14-OP-GP  [TPAD14-OP]  172.82 129.56 180 bottom
TP7601  TPAD14-OP-GP  [TPAD14-OP]  157.96 108.73 0 top
TP7602  TPAD14-OP-GP  [TPAD14-OP]  159.46 108.71 0 top
TP7603  TPAD14-OP-GP  [TPAD14-OP]  176.36 114.29 0 top
TP7604  TPAD14-OP-GP  [TPAD14-OP]  175.09 113.9 0 top
TP7605  TPAD14-OP-GP  [TPAD14-OP]  158.57 109.85 0 top
TP7606  TPAD14-OP-GP  [TPAD14-OP]  183.33 105.5 180 bottom
TP9601  TPAD14-OP-GP  [TPAD14-OP]  78.81 88.27 0 top
TP9602  TPAD14-OP-GP  [TPAD14-OP]  79.45 89.54 0 top
TP9611  TPAD14-OP-GP  [TPAD14-OP]  71.87 90.38 180 bottom
TP9612  TPAD14-OP-GP  [TPAD14-OP]  78.18 89.54 0 top
TP9613  TPAD14-OP-GP  [TPAD14-OP]  81.86 89.79 0 top
TP9614  TPAD14-OP-GP  [TPAD14-OP]  75.64 88.65 180 bottom
TP9615  TPAD14-OP-GP  [TPAD14-OP]  77.01 88.97 180 bottom
TP9616  TPAD14-OP-GP  [TPAD14-OP]  83.43 89 0 top
TP9617  TPAD14-OP-GP  [TPAD14-OP]  74.37 88.65 180 bottom
TP9618  TPAD14-OP-GP  [TPAD14-OP]  82.16 88.24 0 top
TP9619  TPAD14-OP-GP  [TPAD14-OP]  80.77 88.75 0 top
TP9620  TPAD14-OP-GP  [TPAD14-OP]  78.31 81.29 0 top
TP9621  TPAD14-OP-GP  [TPAD14-OP]  80.59 90.87 0 top
TP9622  TPAD14-OP-GP  [TPAD14-OP]  75.84 82.98 180 bottom
TP9623  TPAD14-OP-GP  [TPAD14-OP]  73.73 89.92 180 bottom
TP9624  TPAD14-OP-GP  [TPAD14-OP]  71.88 89.06 180 bottom
TP9626  TPAD14-OP-GP  [TPAD14-OP]  83.13 82.3 0 top
TP9627  TPAD14-OP-GP  [TPAD14-OP]  79.58 81.29 0 top
TP9628  TPAD14-OP-GP  [TPAD14-OP]  78.57 83.03 0 top
TP9629  TPAD14-OP-GP  [TPAD14-OP]  81.86 82.38 0 top
TP9630  TPAD14-OP-GP  [TPAD14-OP]  80.59 82.17 0 top
TP9631  TPAD14-OP-GP  [TPAD14-OP]  79.89 83.33 0 top
TP9632  TPAD14-OP-GP  [TPAD14-OP]  76.41 84.57 0 top
TP9633  TPAD14-OP-GP  [TPAD14-OP]  75.48 83.5 0 top
TP9634  TPAD14-OP-GP  [TPAD14-OP]  77.6 82.29 0 top
TP9635  TPAD14-OP-GP  [TPAD14-OP]  75.82 82.19 0 top
TP9636  TPAD14-OP-GP  [TPAD14-OP]  77.11 83.52 0 top
TP9637  TPAD14-OP-GP  [TPAD14-OP]  82.38 83.72 0 top
TP9638  TPAD14-OP-GP  [TPAD14-OP]  77.67 84.63 0 top
TP9639  TPAD14-OP-GP  [TPAD14-OP]  78.92 84.67 0 top
TP9640  TPAD14-OP-GP  [TPAD14-OP]  78.05 86.49 0 top
TP9641  TPAD14-OP-GP  [TPAD14-OP]  81.22 84.09 0 top
TP9642  TPAD14-OP-GP  [TPAD14-OP]  79.32 86.49 0 top
TP9643  TPAD14-OP-GP  [TPAD14-OP]  76.78 86.49 0 top
TP9644  TPAD14-OP-GP  [TPAD14-OP]  130.12 93.44 0 bottom
TP9645  TPAD14-OP-GP  [TPAD14-OP]  126.04 80.52 180 bottom
TP9646  TPAD14-OP-GP  [TPAD14-OP]  127.33 79.89 0 bottom
TP9647  TPAD14-OP-GP  [TPAD14-OP]  73.1 88.65 180 bottom
TP9648  TPAD14-OP-GP  [TPAD14-OP]  76.65 98.37 0 top
TP9649  TPAD14-OP-GP  [TPAD14-OP]  127.33 78.62 0 bottom
TP9650  TPAD14-OP-GP  [TPAD14-OP]  76.78 91 0 top
TP9651  TPAD14-OP-GP  [TPAD14-OP]  98.37 97.03 180 bottom
TP9652  TPAD14-OP-GP  [TPAD14-OP]  98.37 98.3 180 bottom
TP9653  TPAD14-OP-GP  [TPAD14-OP]  122.62 81.25 180 bottom
TP9654  TPAD14-OP-GP  [TPAD14-OP]  129.21 82.55 180 bottom
TPAD1  ETY-CON10-22-GP-U  [6915K-Q08N-00L]  132.4 91.3 0 top
TR3401  FILTER-4P-6-GP  [FILTER2013-4P-1H44]  22.93 40.88 180 bottom
TR3404  FILTER-4P-6-GP  [FILTER2013-4P-1H44]  25.4 25.89 180 top
TR5208  FILTER-4P-6-GP  [FILTER2013-4P-1H44]  29.02 88.7 180 bottom
TR5209  FILTER-4P-6-GP  [FILTER2013-4P-1H44]  36.14 76.03 90 top
TR6301  FILTER-4P-6-GP  [FILTER2013-4P-1H44]  175.59 12.26 0 top
TR6302  FILTER-4P-6-GP  [FILTER2013-4P-1H44]  175.59 14.93 0 top
U701  74LVC1G07GW-GP  [SC70-5H44]  78.05 94.62 180 top
U2101  SLG59M1470VTR-GP  [DFN9J2015H32]  124.15 102.62 0 bottom
U2901  2N7002KDW-GP  [SOT-363H44]  31.03 17.48 270 bottom
U3101  TVWDF1004AD0-1-GP  [DFN10G2510H26]  32.88 55.31 270 bottom
U3102  TVWDF1004AD0-1-GP  [DFN10G2510H26]  32.88 55.31 270 top
U3401  AZC099-04S-1-GP  [SOT-6H58]  18.67 40.87 270 bottom
U3402  TVWDF1004AD0-1-GP  [DFN10G2510H26]  19.56 25.6 270 bottom
U3403  AZC099-04S-1-GP  [SOT-6H58]  21.11 24.05 270 top
U3501  TPS2000CDGNR-GP  [MSOP8-1G189157H43]  155.52 7.18 90 bottom
U3502  AP2182SG-13-GP  [SOIC8H69]  29.02 30.58 90 top
U3503  SY6288DAAC-GP  [SOT-23-5H56]  39.36 35.63 90 top
U3504  SY6288DAAC-GP  [SOT-23-5H56]  34.49 34.02 180 top
U3505  SY6288DAAC-GP  [SOT-23-5H56]  149.17 4.36 180 bottom
U3601  G5016KD1U-GP  [DFN14J3020-G255D85H32]  131.69 6.83 0 top
U3801  SY6288CCAC-GP  [MSOP8-1H44]  135.89 61.58 180 bottom
U5201  RT9724GB-GP  [SOT-23-5H51]  49.79 74.03 180 top
U5501  TC74VHCT125AFTQK2M-GP  [TSOIC14H48]  23.49 77.05 0 bottom
U5502  RTD2168-CGT-GP  [QFN32-G3D6H40]  16.76 79.95 0 top
U5504  CAT24C128WI-GT3-GP  [SOIC8H69]  26.01 76.55 180 top
U5601  TPS2001CDGNR-GP  [MSOP8-1G189157H43]  194.13 78.24 180 bottom
U5602  AZ1045-04F-R7G-GP  [DFN10G2510H26]  190.45 10.36 270 bottom
U7301  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  152.6 100.73 0 top
U8301  G5016KD1U-GP  [DFN14J3020-G255D85H32]  150.95 120.86 90 top
USB1  SKT-USB13-151-GP  [SKT-USB13-157164]  5.28 25.1 90 bottom
USB2  SKT-USB8-14-GP  [SKT-USB8-166140-2]  1.82 43.1 90 bottom
VRAM1  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  179.54 143.19 270 top
VRAM2  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  179.54 143.19 90 bottom
VRAM3  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  156.24 143.19 270 bottom
VRAM4  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  156.24 143.19 90 top
WLAN1  SKT-MINI52P-81-GP-U1  [AS0B221-S52QW-7H]  184.9 30.7 270 bottom
X1801  XTAL-24MHZ-81-GP  [OSC-3225-4P-4H36]  103.05 104.67 90 bottom
X1901  XTAL-32D768KHZ-65-GP  [SMD49-6914-0403H56]  126.93 65.05 0 bottom
X3001  XTAL-25MHZ-181-GP  [OSC-3225-4P-4H36]  47.65 59.73 270 bottom
X7601  XTAL-27MHZ-85-GP-U  [OSC-3225-4P-4H30]  185.39 110.74 270 bottom
XF3101  XFORM-12P-48-GP  [XFORM12A127097H91]  25.47 55.82 90 bottom
XF3102  XFORM-12P-48-GP  [XFORM12A127097H91]  25.47 55.82 270 top

## Library data of the parts
AFTP2501 AFTP2502 AFTP2801-AFTP2803 AFTP2901-AFTP2904 AFTP2906-AFTP2909 AFTP3101-AFTP3108 AFTP3801-AFTP3803 AFTP3805 AFTP3806 AFTP3901-AFTP3910 AFTP5201-AFTP5214 AFTP5222 AFTP5225-AFTP5228 AFTP6201-AFTP6242 AFTP6245-AFTP6248 AFTP6801 AFTP6802 = AFTE14P-75: tolerance: ZZ.AFT14.101
BAT1 = C144LC-109A7-L-U: tolerance: 20.81925.009
C1-C3 = HOLE197R166: tolerance: ZZ.00PAD.V71
C701 C3509 C3512-C3516 C7518 C7520 C7717 PC4717-PC4722 PC4724-PC4744 PC4923-PC4926 PC5101 PC5108 PC5116-PC5118 = C805H58: tolerance: 78.22610.51L
C702 C1120 C1121 C1201-C1204 C1206 C1210 C1211 C1217 C1218 C1220-C1222 C2110 C2136 C2147 C2401-C2404 C2406-C2410 C2412 C2414 C2417 C2502 C2602 C2605 C2608-C2610 C2612 C2707 C2709 C2710 C2717 C2719 C2720 C3002 C3003 C3007-C3009 C3013 C3017 C3019 C3021-C3025 C3405 C3406 C3501 C3503 C3504 C3507 C3517 C3604 C5201 C5501 C5503 C5517 C5520 C5522 C5524-C5530 C5606 C5802 C5804 C5807 C6201-C6204 C6402 C7316 C7318 C7501-C7506 C7511 C7526 C7601 C7602 C7605 C7711-C7714 C7727 C7729 C7734 C7804 C7820 C7821 C7827 C7829-C7836 C7909 C7910 C7912 C7913 C7921-C7923 C7925 C7927-C7930 C8303 C8306 C8308 C8309 C8311 C9602 EC701 EC702 EC1707 EC2601 EC2708 EC2709 PC4517 PC4518 PC4601 PC4606 PC4610 PC4708 PC4709 PC4824 PC4903 PC4906 PC4915 PC4921 PC8201 = C402H22: tolerance: 78.10421.2FL
C703 C1101-C1103 C1105 C1109 C1111 C1113 C1116-C1118 C1122 C1212-C1216 C1901 C1902 C2104 C2105 C2109 C2114 C2116 C2128 C2135 C2137 C2138 C2416 C2418 C2703 C2704 C2901 C3015 C3018 C3502 C3505 C3506 C3508 C3510 C3518 C3801 C3802 C5206 C7311-C7314 C7319 C7507 C7515 C7516 C7519 C7521 C7525 C7527 C7528 C7530 C7531 C7728 C8302 C8304 EC9718-EC9738 PC4815 PC5109 PC5119 PC5120 = C402H22: tolerance: 78.10523.5FL
C1001-C1006 C1104 C1106-C1108 C1110 C1112 C1114 C1115 C1119 C1123-C1125 C1207-C1209 C2142 C2501 C3603 C3605 C5605 C5609 C5610 C5803 C7517 C7918 C7920 C8307 C8310 PC4723 = C805H54: tolerance: 78.10623.51L
C1017-C1020 C2705 C7606 PC5112 = C402H22: tolerance: 78.22510.5FL
C1205 C2405 C2411 C2413 C5504 = C603H36: tolerance: 78.22523.5BL
C1601-C1612 C3014 C3016 C3403 C3404 C5203 C5209-C5213 = C402H22: tolerance: 78.10421.2FL; signal model: C402H22_SCD1U10V2KX-5GP
C1701 C2415 EC6103 EC6105 PC5111 = C402H22: tolerance: 78.22124.2FL
C1801 C1802 C1903 C1904 C3001 C3011 C7607 C7608 = C402H22: tolerance: 78.15034.1FL
C2101 C2503 PC4210 = C402H22: tolerance: 78.47420.5FL
C2123 C2601 C2712 C2713 C2902 C5502 C5521 C5523 C7320-C7323 C7325-C7328 C7604 C7732 C7813 C7815 PC4916 PC4917 PC8303 PC8307 = C603H38: tolerance: 78.10610.5BL
C2141 C2604 C2611 C2701 C2702 C2706 C2708 C2711 C2715 C2716 C2718 C2907 C2908 C3004 C3005 C3010 C3012 C5204 C5207 C7309 C7310 C7315 C7317 C7324 C7513 C7514 C7603 C7701-C7703 C7708 C7709 C7719-C7726 C7730 C7731 PC4526 PC4920 = C603H36: tolerance: 78.47520.5BL
C2421 PC8217 PC8222 = C402H22: tolerance: 78.47034.1FL
C2422 C2613 EC2905-EC2908 = C402H22: tolerance: 78.10134.1FL
C2603 C2607 C8316 EC4401 = C402H22: tolerance: 78.22224.2FL
C2606 = C603H36: tolerance: 78.47134.1BL
C2723 = C402H22: tolerance: 78.22034.1FL
C3101 = C1808H56: tolerance: 78.1013N.1AL
C3106 C8301 PC4203-PC4205 PC4209 PC4412 PC4425 PC4531 PC4902 PC8204 PC8302 = C402H22: tolerance: 78.10324.2FL
C3401 C3402 EC1701 EC2501 EC2502 = C402H22: tolerance: 78.4R774.1FL
C3601 C3602 C8305 = C402H22: tolerance: 78.47124.2FL
C3701 C3702 = C402H22: tolerance: 78.22321.2FL
C5202 EC1501 EC1502 EC1702-EC1706 EC2704 EC2706 EC2707 EC9708-EC9711 EC9714 EC9740 EC9745 EC9748 PC4521 PC4609 PC4612 PC4613 PC4821 PC8203 PC8205 = C402H22: tolerance: 78.10224.2FL
C5205 EC4304 EC4601 PC4202 PC4401 PC4409 PC4419 PC4514-PC4516 PC4525 PC4530 PC4532 PC4534 PC4535 PC4704 PC4822 PC4825 PC4913 PC4919 PC5110 PC5114 PC8207 PC8211 PC8216 = C603H36: tolerance: 78.10424.2BL
C5208 C5214 EC1801 EC1901 EC2503 EC2602 EC2701 EC3101-EC3108 EC4301 EC4302 EC4305 = C402H22: tolerance: 78.10034.1FL
C5506 C5509 C5510 C5512 C5514 C5518 = C402H22: tolerance: 78.4R7B4.1FL
C5507 C5513 PC4522 PC4523 PC4823 = C402H22: tolerance: 78.18034.1FL
C5511 C5515 = C402H22: tolerance: 78.10134.L1L
C5516 = C402H22: tolerance: 78.10321.2FL
C5519 = C402H22: tolerance: 78.10321.L0L
C5602 C5603 C5607 C5608 C5611 C5612 C5615 C5616 = C402H22: tolerance: 78.10324.2FL; signal model: C402H22_SCD01U16V2KX-3GP
C6401 PC4411 PC4707 = C402H22: tolerance: 78.47322.2FL
C7301-C7308 = C402H22: tolerance: 78.22423.5FL; signal model: C402H22_SCD22U10V2KX-1GP
C7609 C7610 = C402H22: tolerance: 78.27224.2FL
C7710 = C805H54: tolerance: 78.47610.51L
C7733 TC1201 = CT7343H79: tolerance: 79.33719.20L
C7803 C7902 = C402H22: tolerance: 78.82124.2FL
C7805 C7810-C7812 C7814 C7816 C7817 C7822 C7906 C7911 C7915-C7917 C7919 C7924 C7926 PC4524 = C603H36: tolerance: 78.10520.2BL
CCD1 = DM-4260-F08N-00R-01: tolerance: ZZ.F2191.00801
CON1 = 196353-16021-3: tolerance: 20.K0382.016
CPU1 = BGA1168M4024H64: tolerance: 71.HASWE.G0U
CRT1 = 070546HR015M22BZR: tolerance: 020.20020.0015
D2401 D2402 = SOD323AKH40: tolerance: 83.R2004.H8F
D2501 = SOT-23-9H44: tolerance: 75.00040.07D
D2601 D5501 = SOD323AKH38: tolerance: 83.R5003.H8H
D2701 D5201 D5202 D8301 = SOT23-2D4-312H48: tolerance: 75.00054.E7D
D3602 = SOT23-2D4-312H44: tolerance: 83.00016.K11
D4301-D4303 PD4203 = SOT23-2D4-312H44: tolerance: 75.00099.O7D
D7301 = SOT23-2D4-312H44: tolerance: 75.00054.X7D
D7601 D7602 = SOD723AKH27: tolerance: 83.00400.C1F
DB1 = PAD-10P-177042: tolerance: ZZ.00PAD.Y41
DCIN1 = 50299-00701-W01: tolerance: 20.F1783.007
DM1 = 1932208-1-U: tolerance: 62.10017.P41
EC1802 = C402H22: tolerance: 78.10034.1FL; signal model: C402H22_SC10P50V2JN-4GP
EC2703 EC2705 EC4202 EC4303 EC4402 EC4701 EC6104 EC9701-EC9707 EC9712 EC9713 EC9715-EC9717 EC9739 EC9741-EC9744 EC9747 EC9749 PC4402 PC4420 PC4421 PC4423 PC4424 PC4710 PC8202 PC8220 PC8221 PC8225 PC8226 = C402H22: tolerance: 78.10422.5FL
EC2901-EC2904 = C603: tolerance: 78.22224.2BL
EC4201 PC4206 PC4406 PC4415-PC4418 PC4426 PC4519 PC4527 PC4528 PC4701-PC4703 PC4826 PC4912 PC8210 PC8214 PC8215 PC8224 = C805H56: tolerance: 78.10622.51L
EC5205 EC5206 = C402H22: tolerance: 78.6R864.1FL
EC5210 EC6201-EC6206 = C402H22: tolerance: 78.33034.1FL
ED2901-ED2905 = SOD-523-4H28: tolerance: 75.02025.077
EL4201 EL4202 = PAD-2P-4516-U: tolerance: ZZ.00PAD.V91
EL4203 = R1210H24: tolerance: 63.R0007.1BL
F5201 F5203 = POLYSW-4633-UH63: tolerance: 69.60040.001
F5501 = POLYSW-2114H30: tolerance: 69.48001.081
F6201 = POLYSW-2114H50: tolerance: 69.50007.921
FAN1 = 3703K-Q03N-11L: tolerance: 20.F1841.003
FAN261 = SOIC8H69: tolerance: 74.02113.0E1
G1901 = CON2O-U: tolerance: ZZ.CON2O.XXX
GPU1 = BGA595M23H83: tolerance: 71.0N14M.B0U
H1-H3 = HOLE335R115: tolerance: ZZ.00PAD.D01
H4 = HOLE256R115: tolerance: ZZ.00PAD.D11
H5 H6 = HT85BE85R29-U-5: tolerance: ZZ.00PAD.D41
HDA27 = QFN48J6-G465H40: tolerance: 71.03234.003
HDD1 = 127043HR022M25FZR: tolerance: 022.10019.0001
HPMIC1 = 2SJ3080-036111F: tolerance: 022.10002.0001
KB1 KB2 = FL4S030HT6R300-DT: tolerance: 20.K0592.030
KBC24 = LQFP128H63: tolerance: 071.00285.000G
KBLIT1 = 51575-00441-W01: tolerance: 20.K0800.004
L1101 L1102 PR4217 PR4409 PR4701 PR5102 PR8210 PR8211 R2917 R3001 R5229 R5231 R5232 R6205 = R603H22: tolerance: 63.00000.00L
L1103 L1104 = L603H40: tolerance: 68.2R21D.10R
L3001 = L2520-D820H41: tolerance: 68.4R71E.10G
L5501-L5503 = L1608-UH38: tolerance: 68.00084.A11
L7301 = L603H38: tolerance: 68.00335.151
L7501 L7601 = L603H38: tolerance: 68.00335.051
L7602 = L603H38: tolerance: 68.00909.261
LCD1 = 51540-04001-W01: tolerance: 20.K0678.040
LIDSW1 = SOT23-2D8-123H52: tolerance: 74.05712.0BB
LOM30 = QFN32J4-G2D9-U1H36: tolerance: 71.08111.U03
ODD1 = C185A1-11305-L-U: tolerance: 20.81152.013
PC4010 = C603H36: tolerance: 78.47422.5BL
PC4201 = C805H58: tolerance: 78.10594.41L
PC4208 PC4403 PC4404 PC4407 PC4427 PC4431 PC4434 PC4533 = C603H36: tolerance: 78.10522.5BL
PC4408 PC4509 PC4529 PC4814 PC4909 PC4911 PC4914 PC5113 PC5115 PC8208 PC8209 PC8212 PC8213 = C805H54: tolerance: 78.47522.51L
PC4413 = C603H36: tolerance: 78.33224.2BL
PC4422 = C402H22: tolerance: 78.22134.1FL
PC4433 = C402H22: tolerance: 78.47420.8FL
PC4520 = C603: tolerance: 78.33124.2BL
PC4536 PC4838 = C603: tolerance: 78.56124.2BL
PC4604 PC4901 PC4904 = C603H36: tolerance: 78.10523.5BL
PC4611 = C603: tolerance: 78.68224.2BL
PC4706 = C603H40: tolerance: 78.22422.2BL
PC4918 = C402H22: tolerance: 78.22423.5FL
PC4922 PC8206 PC8218 = C402H22: tolerance: 78.33124.2FL
PC8219 = C402H22: tolerance: 78.47034.1FL; signal model: C402H22_SC47P50V2JN-3GP
PC8223 = C402H22: tolerance: 78.56222.2FL
PD4201 = D5436AKH97: tolerance: 83.P6SBM.AAG
PD4204 = SOT-23-10H44: tolerance: 83.0024V.0A1
PD4302 = SOD123FLAKH40: tolerance: 83.SMF18.0AH
PD4401 = SOD323AKH42: tolerance: 83.1R504.A8F
PD4404 = SOD323AKH42: tolerance: 83.04148.D1H
PD4501 = SOD323AKH42: tolerance: 83.15R03.C3F
PD4502 PD4503 = SOT-23-13H51: tolerance: 75.00054.C7D
PG4402-PG4405 PG4407-PG4411 PG4530 PG4532 PG4535 PG4701 PG4702 PG4832 PG4907 PG5104 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PG4412-PG4415 PG4517-PG4529 PG4531 PG4533 PG4534 PG4536-PG4538 PG4540-PG4545 PG4703-PG4708 PG4824-PG4828 PG4830 PG4831 PG4834 PG4837 PG4838 PG4901-PG4906 PG4908-PG4920 PG5101-PG5103 PG5105 PG8201-PG8212 PG8312-PG8315 = GAP-CLOSE-PWR: tolerance: ZZ.CON2d.XXX
PL4401 = L686647H119: tolerance: 68.5R610.10U
PL4501 PL4801 = L736630-MH119: tolerance: 68.2R210.20B
PL4502 = L736630H119: tolerance: 68.3R310.20A
PL4701 = L115100-275300H158: tolerance: 68.R2210.10C
PL4902 = L736630H119: tolerance: 68.R6810.20B
PL5101 = L6965-1332-1H119: tolerance: 68.1R01E.10U
PL8201 PL8202 = L736630H119: tolerance: 68.R3310.201
PQ4201 Q1201 = SOT23DGS2D4H48: tolerance: 84.05067.031
PQ4202 Q2603 Q3002 Q3003 = SOT23CBE2D4H44: tolerance: 84.T3904.H11
PQ4203 PQ4206 PQ4402 PQ4407 PQ4408 PQ4410 PQ8304 PQ8305 Q1701 Q1801 Q2601 Q3601 Q6204 Q7601-Q7603 U2901 = SOT-363H44: tolerance: 84.2N702.A3F
PQ4204 = SOT323CBE2D2H44: tolerance: 84.00124.H1K
PQ4205 = SOT323CBE2D2H44: tolerance: 84.00124.K1K
PQ4208 PQ8306 PQ8307 Q1202 Q1901 Q2401 Q2403 Q2505 Q2602 Q2901 Q3001 Q7301 Q7606 Q8301 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PQ4409 Q2404 = SOT23CBE2D4H44: tolerance: 84.T3906.E11
PQ4414 = SOT23DGS2D4H44: tolerance: 84.2N702.031
PQ8308 = PPAK-5PH45: tolerance: 84.SRA06.037
PR4202 R7638 = R402H16: tolerance: 64.15025.6DL
PR4203 PR4211 PR8258 PR8259 R405 R706 R710 R1510 R1511 R1701 R1717 R1724 R1726 R1902 R1905 R2005 R2008 R2010 R2013 R2015 R2023-R2026 R2414 R2415 R2418 R2436 R2439 R2443 R2453 R2914 R2919 R2920 R3003 R3004 R3021 R3033 R5208 R5604 R6203 R6215 R7303 R7312 R7518 R7601 R7606 R7609 R7612 R7613 R7615 R7621 R7622 R7625-R7628 R7631-R7635 R7637 R7643-R7645 R7647-R7650 R8302 = R402H16: tolerance: 63.10334.1DL
PR4204 R3605 = R402H16: tolerance: 63.22234.1DL
PR4205 PR4206 R5507 R5511 = R402H16: tolerance: 63.33034.1DL
PR4207 = R603H22: tolerance: 63.24434.15L
PR4208 = R603H22: tolerance: 63.47333.15L
PR4209 PR4212 PR4213 PR4216 PR4218 PR4403 PR4417 PR4419 PR4425 PR4428 PR4430 PR4434 PR4438 PR4469 PR4474 PR4534 PR8203 PR8310 PR8311 PR8313 PR8314 R1509 R1715 R1727 R2007 R2412 R2413 R2421 R2426 R2442 R2447 R2711 R2722 R2905 R2918 R3023 R3501 R3502 R3607 R5202 R5607 R6207 R6208 R6401 R7605 R7610 R8301 = R402H16: tolerance: 63.10434.1DL
PR4210 PR4215 PR8256 PR8301 R604 R605 R1702 R1703 R1909 R1919 R2006 R2011 R2012 R2014 R2018 R2432 R2449 R2452 R2502 R2717 R2921 R2922 R3014 R3601 R3603 R3608 R6201 R6214 R9601 = R402H16: tolerance: 63.10234.1DL
PR4214 = R1206H28: tolerance: 63.33232.11L
PR4401 PR4435 PR4439 PR4473 PR4523 PR4822 PR4903 R2405 R7302 R7508-R7512 R7608 R7614 R7618-R7620 = R402H16: tolerance: 64.10025.6DL
PR4402 PR4416 = R3720H40: tolerance: 64.R0105.7FL
PR4404 = R805H24: tolerance: 63.30231.16L
PR4405 R2915 = R402H16: tolerance: 63.47434.1DL
PR4406 PR4422 PR4448 PR4452 PR4465 PR4466 PR4468 PR4471 PR4475 PR4476 PR4501 PR4525 PR4530 PR4535 PR4606 PR4706 PR5112 PR5114 PR8208 R411 R1512 R1704 R1705 R1708 R1710 R1718 R1728 R1729 R1813 R2027 R2030 R2031 R2123 R2411 R2424 R2434 R2437 R2438 R2448 R2450 R2451 R2601 R2602 R2605 R2612 R2710 R2712 R2716 R3704 R3710 R3802 R4910 R5207 R5209 R5222 R5506 R5801 R5804 R5806 R5807 R6204 R6209 R6210 R6212 R6213 R6216 R6217 R6501 R6502 R7304 R7305 R7308 R7313 R7519 R7604 R7623 R7629 R7630 R7636 R7652 R7653 R8303 R8312 R8313 R8315 R9602-R9605 = R402H16: tolerance: 63.R0034.1DL
PR4407 = R402H16: tolerance: 64.30935.6DL
PR4408 = R805H24: tolerance: 63.10031.16L
PR4410 = R402H16: tolerance: 64.6R805.6DL
PR4411 = R402H16: tolerance: 64.10235.6DL
PR4412 PR4415 = R402H16: tolerance: 64.33015.6DL
PR4413 = R402H16: tolerance: 64.84525.6DL
PR4414 = R402H16: tolerance: 63.33534.1DL
PR4418 PR4426 PR4504 PR4506 PR4507 PR4532 PR4621 PR4624 PR4628 PR4819 PR4821 PR4906 PR4907 PR5110 PR8207 PR8257 R404 R1201 R1202 R1205 R1706 R1707 R1709 R1713 R1801 R1810 R1904 R2028 R2029 R2101 R2103 R2105 R2112 R2117 R2118 R2401 R2416 R2417 R2427 R2428 R2430 R2435 R2440 R2441 R2444 R2606 R2611 R2701 R2705 R2708 R2714 R2916 R3005 R3408-R3411 R3609-R3611 R4909 R5201 R5203-R5206 R5212 R5224 R5602 R5802 R5803 R5805 R6104 R6105 R6202 R7624 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ
PR4420 = R402H16: tolerance: 64.7R505.6DL
PR4421 PR4454 PR4604 R2908 R2910 = R402H14: tolerance: 64.10R05.6DL
PR4423 = R402H16: tolerance: 64.59025.6DL
PR4424 = R402H16: tolerance: 64.84515.6DL
PR4427 = R402H16: tolerance: 64.66525.6DL
PR4429 PR5113 = R402H16: tolerance: 64.15035.6DL
PR4431 R709 R712 = R402H16: tolerance: 64.47025.6DL
PR4432 PR4433 PR4436 = R402H16: tolerance: 64.12035.6DL
PR4437 = R402H16: tolerance: 64.16035.6DL
PR4446 PR4904 R2433 R2707 R7639 R7640 = R402H16: tolerance: 64.20025.6DL
PR4464 = R402H16: tolerance: 63.68434.1DL
PR4467 PR5104 R1802 R1901 R7603 R8305 = R402H16: tolerance: 63.10534.1DL
PR4470 PR4472 PR4610 PR5103 R707 R713 R1725 R2406 R2407 R7306 = R402H16: tolerance: 64.10035.6DL
PR4512 = R402H16: tolerance: 64.68015.6DL
PR4517 = R402H16: tolerance: 64.73225.6DL
PR4524 PR4528 = R603H22: tolerance: 63.1R534.15L
PR4526 = R402H16: tolerance: 64.97615.6DL
PR4527 = R402H16: tolerance: 64.15425.6DL
PR4529 PR4533 PR4837 PR4912 PR8215 PR8216 = R805H24: tolerance: 64.2R205.16L
PR4531 = R402H16: tolerance: 64.13735.6DL
PR4601 R703 R5501 R5513 R5514 = R402H16: tolerance: 64.75R05.6DL
PR4602 R6103 = R402H16: tolerance: 64.49905.6DL
PR4603 = R402H16: tolerance: 64.12715.6DL; signal model: R402H16_1K27R2F-L-GP
PR4607 = R402H16: tolerance: 64.12435.6DL
PR4613 = R402H16: tolerance: 64.51015.6DL
PR4614 = R402H16: tolerance: 64.90925.6DL
PR4615 = R402H16: tolerance: 64.38315.6DL
PR4616 PR4618 PR4619 PR8220 PR8221 R1807-R1809 R1811 R1812 R1908 R1911 R2718 R2719 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ; signal model: R402H16_0R2J-2-GP
PR4617 = R402H16: tolerance: 64.16025.6DL
PR4620 = R402H16: tolerance: 64.54R95.6DL
PR4622 = NTC-402H22-U: tolerance: 69.60037.001
PR4630 R704 = R402H16: tolerance: 64.13005.6DL
PR4702 = R402H16: tolerance: 64.36515.6DL
PR4703 = R402H16: tolerance: 64.44215.6DL
PR4704 = NTC-402H22-U: tolerance: 69.60037.011
PR4705 = R402H16: tolerance: 64.35705.6DL
PR4707 = R402H16: tolerance: 64.10055.6DL
PR4708 = R402H16: tolerance: 64.11025.6DL
PR4817 = R402H16: tolerance: 64.10535.60L
PR4820 PR4905 R2403 = R603H22: tolerance: 64.2R205.55L
PR4823 = R402H16: tolerance: 64.21025.6DL
PR4824 PR5111 = R402H16: tolerance: 64.47035.6DL
PR4901 R7642 = R402H16: tolerance: 64.30125.6DL
PR4902 = R402H16: tolerance: 64.13335.6DL
PR4908 = R402H16: tolerance: 64.10015.6DL
PR4911 R711 R1102-R1104 R2102 R2108 R2402 R2703 R2901-R2904 R2906 R2907 R2909 R2911 R2923 R3006 R5230 R5503 R5504 = 0R0603-PAD-U: tolerance: ZZ.R0603.001
PR8201 = R402H16: tolerance: 64.49935.6DL
PR8202 = R402H16: tolerance: 64.2R205.6DL
PR8206 = R402H16: tolerance: 64.75015.6DL
PR8209 = R402H16: tolerance: 64.78715.6DL
PR8212 PR8213 R409 R702 R901 = R402H14: tolerance: 64.10005.6DL
PR8222 = R402H16: tolerance: 64.27025.6DL
PR8223 = R603H22: tolerance: 63.2R233.15L
PR8224 = R402H16: tolerance: 64.80615.6DL
PR8260 = R402H16: tolerance: 64.13025.6DL
PR8312 R1720 R1721 R1903 R1913 R2425 R2431 = R402H16: tolerance: 63.33434.1DL
PR8315-PR8317 = R402H14: tolerance: 63.10034.1DL
PT4501 PT4502 = SE361414H178: tolerance: 79.22710.3KL
PT4701 = SE361416H178: tolerance: 77.53371.18L
PT4702 = SE361413H182: tolerance: 79.33612.6CL
PT4803 PT8206-PT8208 = SE361414H178: tolerance: 79.3371V.6CL
PU4201 PU4402 PU4403 = PPAK-8P-2H45: tolerance: 84.07121.037
PU4404 = QFN20G3D5-G2D15H40: tolerance: 74.02224.073
PU4405 PU4406 PU4501 PU4504 PU4505 PU4805 PU4808 PU4902 = PPAK-8P-2H45: tolerance: 84.00412.037
PU4407 = SC70-6H44: tolerance: 74.00199.07P
PU4502 PU4903 = PPAK-8P-2H45: tolerance: 84.00780.037
PU4503 = QFN20-G1D75H32: tolerance: 74.51225.073
PU4601 = QFN20G4030-G275175H40: tolerance: 74.95813.B73
PU4701 = PPAK-8P-G5324H44-COLAY: tolerance: ZZ.00215.037
PU4806 = DFN10G3-G265175H32: tolerance: 74.08237.B73
PU4901 = QFN20-G1D75H32: tolerance: 74.51716.073
PU5101 = SOT-23-5H58: tolerance: 74.70215.03F
PU5102 = QFN10M3-G4P-UH34: tolerance: 74.08208.K73
PU8201 = QFN20-G1D75H32: tolerance: 74.08812.073
PU8202 PU8204 PU8206 PU8208 = PPAK-5PH45: tolerance: 84.A14DP.037
PU8203 PU8205 PU8207 PU8209 = PPAK-5PH45: tolerance: 84.SRA12.037
Q2402 Q3004 Q6203 Q8302 = SOT23DGS2D4H48: tolerance: 84.02130.031
Q3602 = SOT23CBE2D4H44: tolerance: 84.02222.V11
Q6103 Q6104 Q6201 = SOT23CBE2D4H44: tolerance: 84.00144.N11
Q6202 = SOT23DGS2D4H48: tolerance: 84.03404.C31
R401 = R402H16: tolerance: 63.62034.1DL
R402 R406 R1916-R1918 R1920 = R402H16: tolerance: 63.51034.1DL
R403 = R402H16: tolerance: 63.56034.1DL
R407 R7307 = R402H16: tolerance: 64.20005.6DL
R408 = R402H16: tolerance: 64.12105.6DL
R410 = R402H16: tolerance: 63.47134.1DL
R601 R602 R606 R2003 = R402H16: tolerance: 64.49R95.6DL
R603 R1714 = R402H16: tolerance: 64.82015.6DL
R701 = R402H16: tolerance: 63.43034.1DL; signal model: R402H16_43R2J-GP
R705 = R402H16: tolerance: 63.15134.1DL
R801 R3707 R3711 = R402H16: tolerance: 64.24R95.6DL
R1101 R1105 R2702 R2704 R2706 = 0R0805-PAD-U: tolerance: ZZ.R0805.001
R1204 = R402H16: tolerance: 63.20534.1DL
R1206 R1207 = R402H16: tolerance: 64.66R55.6DL
R1208 = R402H16: tolerance: 63.22434.1DL
R1601 R1803 R1906 = R402H16: tolerance: 64.30015.6DL
R1602 = R402H16: tolerance: 64.22R65.6DL
R1804 R2720 = R402H16: tolerance: 63.R0034.1DL; signal model: R402H16_0R2J-2-GP
R1805 R1806 R1907 R1912 R2419 R2420 R2422 R2423 = R402H16: tolerance: 63.33034.1DL; signal model: R402H16_33R2J-2-GP
R1915 R2504 = R402H16: tolerance: 63.10634.1DL
R2001 R2002 R2004 R2009 R2016 R2017 R2020 R2022 R2408-R2410 = 0R0402-PAD: tolerance: ZZ.R0402.001
R2110 = R402H16: tolerance: 64.5R105.6DL
R2114 R2122 R3801 R5211 R5603 R8304 = R805H24: tolerance: 63.R0031.16L
R2404 R2446 = R402H16: tolerance: 64.64925.6DL
R2429 = R402H16: tolerance: 63.43034.1DL
R2445 = R402H16: tolerance: 64.57625.6DL
R2501 R2912 R2913 R3606 R5502 R5508 R5509 R5512 R5515 R5516 R6211 = R402H16: tolerance: 63.47234.1DL
R2603 = R402H16: tolerance: 64.18725.6DL
R2604 R2607 R4622 = R402H16: tolerance: 64.20015.6DL
R2608 R2609 R7641 = R402H16: tolerance: 64.24925.6DL
R2610 = NTC-603H38: tolerance: 69.60035.041
R2709 R3602 = R402H16: tolerance: 64.20035.6DL
R3015 = R402H16: tolerance: 63.15334.1DL
R3016 = 0R0603-PAD: tolerance: ZZ.R0603.ZZZ
R3022 = R402H16: tolerance: 63.20334.1DL
R3032 R7301 = R402H16: tolerance: 64.24915.6DL
R3701 R3703 R3706 R3709 = R402H16: tolerance: 64.18015.6DL
R3702 R3708 = R402H16: tolerance: 64.2R005.6DL
R5210 R5233 R6102 = R402H14: tolerance: 63.10134.1DL
R5505 = R402H16: tolerance: 64.12025.6DL
R5510 = R402H15: tolerance: 63.10434.L1L
R6101 = R402H16: tolerance: 63.33134.1DL
R6206 = R402H16: tolerance: 63.51334.1DL
R7501 R7503 = R402H16: tolerance: 64.60R45.6DL
R7505 = R402H16: tolerance: 64.40R25.6DL
R7506 = R402H16: tolerance: 64.51R15.6DL
R7507 = R402H16: tolerance: 64.42R25.6DL
R7602 R7617 R7646 = R402H16: tolerance: 64.49925.6DL
R7607 = R402H16: tolerance: 64.40225.6DL
R7611 R7616 R7651 = R402H16: tolerance: 64.49915.6DL
R7806 R7807 R7903 R7904 = R402H16: tolerance: 64.13315.6DL
R7808 R7809 R7912 R7913 = R402H16: tolerance: 64.24305.6DL
R7810 R7914 = R402H16: tolerance: 64.16205.6DL
R8314 = R402H16: tolerance: 63.75434.1DL
RJ45 = C100HR-10805-L: tolerance: 022.10001.0551
RN401 = ARES8-CN24H22: tolerance: 66.51036.A8L
RN1501 RN1811 RN2602 RN2901 RN5501 RN7603-RN7605 = ARES2H16: tolerance: 66.22236.04L
RN1503 RN1701 RN1703 RN1803 RN1804 RN1810 RN2006-RN2008 RN3001 RN6201 RN6204 RN7401-RN7404 RN7602 = ARES2H18: tolerance: 66.10336.04L
RN1505 RN1601 RN1801 RN1809 RN1902 RN2002 RN2011 RN2012 = ARES8-CN24-MUH20: tolerance: 66.10336.08L
RN1702 RN2701 RN5502 RN9601 = SMD-ARES4H20: tolerance: 66.R0036.04L
RN1802 = SMD-ARES4H18: tolerance: 66.10236.04L
RN1806 RN6501 = ARES8-CN24H22: tolerance: 66.R0036.A8L
RN1807 = ARES8-CN24-UH20: tolerance: 66.22236.A8L
RN1901 = SMD-ARES4H20: tolerance: 66.20336.04L
RN2401 RN2501 RN7601 = SMD-ARES4H18: tolerance: 66.47236.04L
RN3101 = ARES8-CN24H22: tolerance: 66.75036.08L
RN4301 RN5201 = ARES8-CN24H20: tolerance: 66.10136.A8L
RN5202 RN5204 RN6202 RN6203 = SMD-ARES4H18: tolerance: 66.33036.04L
RN5203 = ARES8-CN24H20: tolerance: 66.10436.A8L
RN5205 RN5206 = SMD-ARES4H20: tolerance: 66.R0036.04L; signal model: SMD-ARES4H20_SRN0J-6-GP
RTC1 = 060003HA002M213ZL-U2: tolerance: 62.70014.001
S1 S2 = STF237R117H83: tolerance: 34.4CK01.001
SKT25 = G6179HT0321-001: tolerance: 62.10089.011
SPI25 = SOIC8-1H86: tolerance: 72.25Q64.K01
SPK1 = 50224-0040N-001: tolerance: 20.F1639.004
SPR2 SPR3 = SPR5930H154: tolerance: 34.41V01.001
SPR4 = SPR4527H308: tolerance: 34.15J03.001
SPR5 = SPR5630H142: tolerance: 34.4Y806.001
SW1 = 6916K-Q04M-00L: tolerance: 20.K0465.004
TC3501 TC3502 TC6301 = C1206H71: tolerance: 78.10710.52L
THM26 = MSOP8-1H44: tolerance: 74.07718.0B9
TP402 TP403 TP501 TP601-TP608 TP619 TP620 TP701-TP705 TP801 TP1501 TP1502 TP1601 TP1602 TP1702-TP1707 TP1801-TP1803 TP1901 TP1902 TP2001-TP2003 TP2101-TP2109 TP2201-TP2208 TP2702 TP3001-TP3003 TP5101 TP5801-TP5804 TP7501-TP7505 TP7601-TP7606 TP9601 TP9602 TP9611-TP9624 TP9626-TP9654 = TPAD14-OP: tolerance: ZZ.PAD14.001
TPAD1 = 6915K-Q08N-00L: tolerance: 20.K0665.008
TR3401 TR3404 TR5208 TR5209 TR6302 = FILTER2013-4P-1H44: tolerance: 69.10103.041; signal model: FILTER2013-4P-1H44_FILTER-4P-6-GP
