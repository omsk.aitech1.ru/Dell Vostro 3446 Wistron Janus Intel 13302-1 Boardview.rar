# Allegro board Janus Intel MB_13302-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
EC6203  SC33P50V2JN-3GP  [C402H22]  127.75 97.88 0 bottom
EC6204  SC33P50V2JN-3GP  [C402H22]  127.75 96.16 180 bottom
EC6205  SC33P50V2JN-3GP  [C402H22]  132.89 95.67 180 bottom
EC6206  SC33P50V2JN-3GP  [C402H22]  135.05 96.87 270 bottom
EC9701  SCD1U25V2KX-GP  [C402H22]  132.09 136.91 180 top
EC9702  SCD1U25V2KX-GP  [C402H22]  150.5 60.46 180 top
EC9703  SCD1U25V2KX-GP  [C402H22]  99.7 11.17 180 top
EC9704  SCD1U25V2KX-GP  [C402H22]  140.66 35.12 270 top
EC9705  SCD1U25V2KX-GP  [C402H22]  111.2 124.4 180 bottom
EC9706  SCD1U25V2KX-GP  [C402H22]  87.5 129.56 0 top
EC9707  SCD1U25V2KX-GP  [C402H22]  55.09 89.27 270 top
EC9708  SC1KP50V2KX-1GP  [C402H22]  108.2 2.88 0 top
EC9709  SC1KP50V2KX-1GP  [C402H22]  113.14 19.38 270 top
EC9710  SC1KP50V2KX-1GP  [C402H22]  119.32 33.85 90 top
EC9711  SC1KP50V2KX-1GP  [C402H22]  154.25 93.79 180 top
EC9712  SCD1U25V2KX-GP  [C402H22]  154.25 69.92 180 top
EC9713  SCD1U25V2KX-GP  [C402H22]  134.44 123.26 270 top
EC9714  SC1KP50V2KX-1GP  [C402H22]  148.95 110.3 90 top
EC9715  SCD1U25V2KX-GP  [C402H22]  135.39 108.98 270 top
EC9716  SCD1U25V2KX-GP  [C402H22]  55.5 95.39 270 top
EC9717  SCD1U25V2KX-GP  [C402H22]  86.73 125.76 180 bottom
EC9718  SC1U10V2KX-1GP  [C402H22]  72.82 2.91 0 top
EC9719  SC1U10V2KX-1GP  [C402H22]  45.15 3.11 90 bottom
EC9720  SC1U10V2KX-1GP  [C402H22]  167.18 10.03 180 top
EC9721  SC1U10V2KX-1GP  [C402H22]  187.98 7.47 180 bottom
EC9722  SC1U10V2KX-1GP  [C402H22]  134.66 6.31 180 top
EC9723  SC1U10V2KX-1GP  [C402H22]  191.62 72.61 90 bottom
EC9724  SC1U10V2KX-1GP  [C402H22]  30.16 71.55 270 top
EC9725  SC1U10V2KX-1GP  [C402H22]  181.43 56.71 180 bottom
EC9726  SC1U10V2KX-1GP  [C402H22]  156.56 152.7 180 top
EC9727  SC1U10V2KX-1GP  [C402H22]  194.98 111.6 90 bottom
EC9728  SC1U10V2KX-1GP  [C402H22]  156.39 131.61 0 top
EC9729  SC1U10V2KX-1GP  [C402H22]  155.43 152.72 180 top
EC9730  SC1U10V2KX-1GP  [C402H22]  196.8 134.7 270 bottom
EC9731  SC1U10V2KX-1GP  [C402H22]  163.42 131.44 0 top
EC9732  SC1U10V2KX-1GP  [C402H22]  137.38 7.41 0 top
EC9733  SC1U10V2KX-1GP  [C402H22]  104.43 9.09 0 bottom
EC9734  SC1U10V2KX-1GP  [C402H22]  138.27 7.41 0 top
EC9735  SC1U10V2KX-1GP  [C402H22]  18.09 93.35 90 bottom
EC9736  SC1U10V2KX-1GP  [C402H22]  41.72 71.34 270 bottom
EC9737  SC1U10V2KX-1GP  [C402H22]  25.2 21.67 90 bottom
EC9738  SC1U10V2KX-1GP  [C402H22]  128.39 3.71 0 top
EC9739  SCD1U25V2KX-GP  [C402H22]  33.28 20.91 180 top
EC9740  SC1KP50V2KX-1GP  [C402H22]  115.15 132.64 270 top
EC9741  SCD1U25V2KX-GP  [C402H22]  147.3 123.66 270 top
EC9742  SCD1U25V2KX-GP  [C402H22]  122.98 128 0 top
EC9743  SCD1U25V2KX-GP  [C402H22]  32.45 20.91 180 top
EC9744  SCD1U25V2KX-GP  [C402H22]  31.62 20.91 180 top
EC9745  SC1KP50V2KX-1GP  [C402H22]  28.67 8.83 180 bottom
EC9747  SCD1U25V2KX-GP  [C402H22]  111.96 131.89 270 bottom
EC9748  SC1KP50V2KX-1GP  [C402H22]  141.55 140.4 270 bottom
EC9749  SCD1U25V2KX-GP  [C402H22]  151.39 61.23 180 bottom
ED2901  AZ2025-01H-R7G-GP  [SOD-523-4H28]  23.49 10.31 270 top
ED2902  AZ2025-01H-R7G-GP  [SOD-523-4H28]  19.63 3.62 0 top
ED2903  AZ2025-01H-R7G-GP  [SOD-523-4H28]  16.54 3.57 0 top
ED2904  AZ2025-01H-R7G-GP  [SOD-523-4H28]  23.49 8.51 270 top
ED2905  AZ2025-01H-R7G-GP  [SOD-523-4H28]  23.49 6.7 270 top
EL4201  PAD-2P-4516-GP-U  [PAD-2P-4516-U]  99.82 145.71 0 bottom
EL4202  PAD-2P-4516-GP-U  [PAD-2P-4516-U]  102.42 145.93 0 bottom
EL4203  0R0J-GP  [R1210H24]  103.12 151.43 90 bottom
F5201  POLYSW-1D1A24V-2-GP  [POLYSW-4633-UH63]  56.08 85.79 0 top
F5203  POLYSW-1D1A24V-2-GP  [POLYSW-4633-UH63]  31.82 74.24 270 top
F5501  POLYSW-1D1A6V-9-GP-U  [POLYSW-2114H30]  11.83 92.93 270 bottom
F6201  POLYSW-D5A6V-1-GP  [POLYSW-2114H50]  137.89 76.29 270 bottom
FAN1  ETY-CON3-8-GP  [3703K-Q03N-11L]  47.78 92.43 270 bottom
FAN261  AP2113MTR-G1-GP  [SOIC8H69]  31.95 93.41 270 bottom
G1901  GAP-OPEN  [CON2O-U]  120.85 62.74 270 top
GPU1  N14M-GE-S-A2-GP  [BGA595M23H83]  167.85 115.39 90 bottom
H1  HOLE335R115-GP  [HOLE335R115]  116.1 152.7 0 top
H2  HOLE335R115-GP  [HOLE335R115]  19.9 16.2 0 top
H3  HOLE335R115-GP  [HOLE335R115]  24.8 67.4 0 top
H4  HOLE256R115-GP  [HOLE256R115]  194.9 62.4 0 top
H5  HT85BE85R29-U-5-GP  [HT85BE85R29-U-5]  175.4 5.2 0 top
H6  HT85BE85R29-U-5-GP  [HT85BE85R29-U-5]  197.94 141.4 0 bottom
HDA27  ALC3234-CG-GP  [QFN48J6-G465H40]  35.63 10.74 270 top
HDD1  SKT-SATA7P-15P-159-GP  [127043HR022M25FZR]  198.74 23.03 270 bottom
HPMIC1  AUDIO-JK430-GP  [2SJ3080-036111F]  3.5 8.1 90 bottom
KB1  ACES-CON30-10-GP  [FL4S030HT6R300-DT]  183.8 93.86 270 top
KB2  ACES-CON30-10-GP  [FL4S030HT6R300-DT]  194.9 121.9 270 top
KBC24  NPCE285PA0DX-GP  [LQFP128H63]  169.89 29.9 270 top
KBLIT1  ACES-CON4-56-GP  [51575-00441-W01]  134.43 103.05 90 top
L1101  0R3J-0-U-GP  [R603H22]  113.79 104.72 90 bottom
L1102  0R3J-0-U-GP  [R603H22]  117.08 104.53 90 bottom
L1103  IND-2D2UH-196-GP  [L603H40]  113.48 105.22 270 top
L1104  IND-2D2UH-196-GP  [L603H40]  110.44 104.46 270 top
L3001  IND-4D7UH-242-GP  [L2520-D820H41]  45.99 64.67 0 bottom
L5501  BLM18BB220SN-GP  [L1608-UH38]  10.72 80.66 0 top
L5502  BLM18BB220SN-GP  [L1608-UH38]  10.72 84.24 180 top
L5503  BLM18BB220SN-GP  [L1608-UH38]  10.72 78.07 0 top
L7301  MHC1608S121PBP-GP  [L603H38]  161.67 114.39 0 top
L7501  MHC1608S300QBP-GP  [L603H38]  163.27 119.88 270 top
L7601  MHC1608S300QBP-GP  [L603H38]  172.22 106.45 270 top
L7602  MCB1608S181FBP-GP  [L603H38]  170.76 101.74 270 top
LCD1  ACES-CON40-18-GP  [51540-04001-W01]  37.2 86.7 180 top
LIDSW1  S-5712ACDL1-M3T1U-GP  [SOT23-2D8-123H52]  2.8 73.6 270 top
LOM30  RTL8111G-CGT-1-GP-U1  [QFN32J4-G2D9-U1H36]  40.39 60.82 0 bottom
NOREF  -  []  84.58 49.73 0 top
NOREF#2  -  []  184.22 154.88 0 top
NOREF#3  -  []  4.9 -23.3 0 top
NOREF#4  *  [unnamed#2]  188.92 154.5 0 top
NOREF#5  *  [unnamed#2]  150.12 48.59 0 top
NOREF#6  -  [unnamed#2]  206.66 -0.48 0 top
NOREF#7  -  [unnamed#2]  192.53 3.75 0 top
NOREF#8  -  [unnamed#2]  167.7 154.4 0 top
NOREF#9  -  []  90.37 164.03 0 top
NOREF#10  -  []  4.9 -23.3 0 top
NOREF#11  -  []  4.9 -23.3 0 top
NOREF#12  -  []  4.9 -23.3 0 top
NOREF#13  *  [unnamed#2]  44.55 23.47 0 top
NOREF#14  *  [unnamed#2]  92.6 5.66 0 top
NOREF#15  -  [unnamed#2]  198.19 53.13 0 top
NOREF#16  -  [unnamed#2]  206.77 165.96 0 top
NOREF#17  -  []  4.9 -23.3 0 top
NOREF#18  -  [unnamed#2]  189.28 164.18 0 top
NOREF#19  *  [unnamed#2]  208.93 13.68 0 top
NOREF#20  -  []  20.98 171.2 0 top
NOREF#21  -  []  0.33 111.07 270 top
NOREF#22  -  [unnamed#2]  61.33 110.42 0 top
NOREF#23  *  [unnamed#2]  25.73 3.12 0 top
NOREF#24  -  []  4.9 -23.3 0 top
NOREF#25  -  [unnamed#2]  25.83 94.94 0 top
NOREF#26  *  [unnamed#2]  167.61 1.52 0 top
NOREF#27  -  []  213.56 52.52 90 top
NOREF#28  -  []  4.9 -23.3 0 top
NOREF#29  *  [unnamed#2]  206.75 157.37 0 top
NOREF#30  *  [unnamed#2]  13.09 161.75 0 top
NOREF#31  *  [unnamed#2]  180.32 22.1 0 top
NOREF#32  -  [unnamed#2]  20.47 35.2 270 top
NOREF#33  -  [unnamed#2]  2.72 165.64 0 top
NOREF#34  -  []  46.43 96.08 0 top
NOREF#35  -  []  196.67 122.83 180 bottom
NOREF#36  -  []  37.98 119.59 180 bottom
NOREF#37  *  [unnamed#2]  25.73 3.12 180 bottom
NOREF#38  *  [unnamed#2]  13.09 161.75 180 bottom
NOREF#39  *  [unnamed#2]  180.6 63.36 180 bottom
NOREF#40  *  [unnamed#2]  188.92 154.5 180 bottom
NOREF#41  *  [unnamed#2]  154.51 92.4 180 bottom
NOREF#42  *  [unnamed#2]  169.03 3.09 180 bottom
NOREF#43  -  []  184.22 154.88 180 bottom
NOREF#44  *  [unnamed#2]  208.93 13.68 180 bottom
NOREF#45  *  [unnamed#2]  46.17 54.81 180 bottom
NOREF#46  *  [unnamed#2]  206.75 157.37 180 bottom
NOREF#47  *  [unnamed#2]  34.24 68.01 180 bottom
NOREF#48  -  []  12.39 96.46 180 bottom
NOREF#49  -  []  101.97 52.46 180 bottom
NOREF#50  -  []  104.72 164.03 180 bottom
ODD1  SKT-SATA7P+6P-57-GP-U  [C185A1-11305-L-U]  201.55 76.9 270 bottom
PC4010  SCD47U25V3KX-1GP  [C603H36]  108.4 134.71 180 bottom
PC4201  SC1U50V5ZY-1-GP-U  [C805H58]  95.2 148.58 180 bottom
PC4202  SCD1U50V3KX-GP  [C603H36]  97.79 145.91 180 bottom
PC4203  SCD01U50V2KX-1GP  [C402H22]  86.51 152.19 90 bottom
PC4204  SCD01U50V2KX-1GP  [C402H22]  86.51 151.3 90 bottom
PC4205  SCD01U50V2KX-1GP  [C402H22]  86.51 150.41 90 bottom
PC4206  SC10U25V5KX-GP  [C805H56]  87.58 149.04 90 bottom
PC4208  SC1U25V3KX-1-GP  [C603H36]  96.47 145.91 180 bottom
PC4209  SCD01U50V2KX-1GP  [C402H22]  109.65 144.31 270 bottom
PC4210  SCD47U6D3V2KX-GP  [C402H22]  109.14 147.26 180 bottom
PC4401  SCD1U50V3KX-GP  [C603H36]  101.29 133.29 90 bottom
PC4402  SCD1U25V2KX-GP  [C402H22]  105.1 132.53 90 top
PC4403  SC1U25V3KX-1-GP  [C603H36]  106.37 133.67 90 top
PC4404  SC1U25V3KX-1-GP  [C603H36]  103.96 133.67 270 top
PC4406  SC10U25V5KX-GP  [C805H56]  112.47 138.37 0 bottom
PC4407  SC1U25V3KX-1-GP  [C603H36]  110.44 138.63 0 bottom
PC4408  SC4D7U25V5KX-GP  [C805H54]  113.87 138.37 180 top
PC4409  SCD1U50V3KX-GP  [C603H36]  114.12 138.37 0 bottom
PC4411  SCD047U25V2KX-GP  [C402H22]  106.75 136.34 90 top
PC4412  SCD01U50V2KX-1GP  [C402H22]  102.94 136.85 90 top
PC4413  SC3300P50V3KX-1GP  [C603H36]  109.17 137.61 180 top
PC4415  SC10U25V5KX-GP  [C805H56]  142.31 148.91 270 bottom
PC4416  SC10U25V5KX-GP  [C805H56]  142.31 147.01 270 bottom
PC4417  SC10U25V5KX-GP  [C805H56]  142.31 148.91 90 top
PC4418  SC10U25V5KX-GP  [C805H56]  142.31 147.01 90 top
PC4419  SCD1U50V3KX-GP  [C603H36]  142.44 150.56 90 top
PC4420  SCD1U25V2KX-GP  [C402H22]  104.42 141.88 0 top
PC4421  SCD1U25V2KX-GP  [C402H22]  104.01 142.64 90 bottom
PC4422  SC220P50V2JN-3GP  [C402H22]  102.94 137.74 90 top
PC4423  SCD1U25V2KX-GP  [C402H22]  103.58 141.88 0 top
PC4424  SCD1U25V2KX-GP  [C402H22]  123.23 145.64 0 top
PC4425  SCD01U50V2KX-1GP  [C402H22]  108.53 131.26 180 bottom
PC4426  SC10U25V5KX-GP  [C805H56]  111.96 138.37 180 top
PC4427  SC1U25V3KX-1-GP  [C603H36]  120.72 148.28 270 top
PC4431  SC1U25V3KX-1-GP  [C603H36]  117.8 145.63 180 top
PC4433  SCD47U6D3V2KX-1-GP  [C402H22]  111.87 147.52 0 top
PC4434  SC1U25V3KX-1-GP  [C603H36]  141.17 144.52 270 top
PC4509  SC4D7U25V5KX-GP  [C805H54]  123.52 32.58 90 top
PC4514  SCD1U50V3KX-GP  [C603H36]  135.23 41.42 90 top
PC4515  SCD1U50V3KX-GP  [C603H36]  139.39 36.52 0 bottom
PC4516  SCD1U50V3KX-GP  [C603H36]  135.2 37.94 270 top
PC4517  SCD1U16V2KX-3GP  [C402H22]  120.09 10.61 90 bottom
PC4518  SCD1U16V2KX-3GP  [C402H22]  139.14 10.48 270 bottom
PC4519  SC10U25V5KX-GP  [C805H56]  127.71 33.85 270 top
PC4520  SC330P50V3KX-GP  [C603]  128.85 28.9 180 top
PC4521  SC1KP50V2KX-1GP  [C402H22]  134.87 39.03 90 top
PC4522  SC18P50V2JN-1-GP  [C402H22]  131.98 41.67 90 bottom
PC4523  SC18P50V2JN-1-GP  [C402H22]  127.33 42.11 0 top
PC4524  SC1U6D3V3KX-2GP  [C603H36]  130.71 33.65 0 top
PC4525  SCD1U50V3KX-GP  [C603H36]  123.52 30.93 90 top
PC4526  SC4D7U6D3V3KX-GP  [C603H36]  131.06 42.44 180 top
PC4527  SC10U25V5KX-GP  [C805H56]  136.22 32.33 270 top
PC4528  SC10U25V5KX-GP  [C805H56]  123.52 32.58 270 bottom
PC4529  SC4D7U25V5KX-GP  [C805H54]  136.22 32.33 90 bottom
PC4530  SCD1U50V3KX-GP  [C603H36]  136.22 30.68 270 top
PC4531  SCD01U50V2KX-1GP  [C402H22]  129.61 33.98 0 top
PC4532  SCD1U50V3KX-GP  [C603H36]  135.23 40.1 90 top
PC4533  SC1U25V3KX-1-GP  [C603H36]  139.65 44.14 270 bottom
PC4534  SCD1U50V3KX-GP  [C603H36]  133.58 39.18 90 bottom
PC4535  SCD1U50V3KX-GP  [C603H36]  124.97 37.42 90 top
PC4536  SC560P50V-GP  [C603]  130.88 28.9 180 top
PC4601  SCD1U16V2KX-3GP  [C402H22]  119.78 125.83 270 top
PC4604  SC1U10V3KX-3GP  [C603H36]  112.25 121.53 270 top
PC4606  SCD1U16V2KX-3GP  [C402H22]  120.03 115.3 180 top
PC4609  SC1KP50V2KX-1GP  [C402H22]  118.73 120.51 270 bottom
PC4610  SCD1U16V2KX-3GP  [C402H22]  118.73 121.53 90 bottom
PC4611  SC6800P50V3KX-GP  [C603]  116.45 122.41 90 bottom
PC4612  SC1KP50V2KX-1GP  [C402H22]  117.96 123.55 90 top
PC4613  SC1KP50V2KX-1GP  [C402H22]  118.5 125.41 180 top
PC4701  SC10U25V5KX-GP  [C805H56]  108.02 119.07 0 top
PC4702  SC10U25V5KX-GP  [C805H56]  109.93 119.07 180 bottom
PC4703  SC10U25V5KX-GP  [C805H56]  109.93 119.07 0 top
PC4704  SCD1U50V3KX-GP  [C603H36]  108.28 119.07 180 bottom
PC4706  SCD22U25V3KX-GP  [C603H40]  112.25 118.99 90 top
PC4707  SCD047U25V2KX-GP  [C402H22]  114.41 124.86 180 top
PC4708  SCD1U16V2KX-3GP  [C402H22]  115.29 124.86 180 top
PC4709  SCD1U16V2KX-3GP  [C402H22]  116.56 126.12 90 top
PC4710  SCD1U25V2KX-GP  [C402H22]  114.79 126.12 270 top
PC4717  SC22U6D3V5MX-2GP  [C805H58]  95.58 87.19 0 top
PC4718  SC22U6D3V5MX-2GP  [C805H58]  69.71 89.84 270 top
PC4719  SC22U6D3V5MX-2GP  [C805H58]  101.29 87.19 0 top
PC4720  SC22U6D3V5MX-2GP  [C805H58]  91.77 87.19 0 top
PC4721  SC22U6D3V5MX-2GP  [C805H58]  69.62 86.03 270 top
PC4722  SC22U6D3V5MX-2GP  [C805H58]  85.75 117.54 270 top
PC4723  SC10U10V5KX-2GP  [C805H54]  85.75 119.45 270 top
PC4724  SC22U6D3V5MX-2GP  [C805H58]  69.76 97.47 270 top
PC4725  SC22U6D3V5MX-2GP  [C805H58]  92.61 108.3 270 bottom
PC4726  SC22U6D3V5MX-2GP  [C805H58]  93.67 87.19 0 top
PC4727  SC22U6D3V5MX-2GP  [C805H58]  92.61 106.26 270 bottom
PC4728  SC22U6D3V5MX-2GP  [C805H58]  69.59 84.15 270 top
PC4729  SC22U6D3V5MX-2GP  [C805H58]  92.61 104.23 270 bottom
PC4730  SC22U6D3V5MX-2GP  [C805H58]  92.61 110.2 270 bottom
PC4731  SC22U6D3V5MX-2GP  [C805H58]  92.61 112.11 270 bottom
PC4732  SC22U6D3V5MX-2GP  [C805H58]  86.56 83.89 90 top
PC4733  SC22U6D3V5MX-2GP  [C805H58]  89.86 87.19 0 top
PC4734  SC22U6D3V5MX-2GP  [C805H58]  87.96 87.19 0 top
PC4735  SC22U6D3V5MX-2GP  [C805H58]  86.15 116.95 90 bottom
PC4736  SC22U6D3V5MX-2GP  [C805H58]  69.89 87.94 270 top
PC4737  SC22U6D3V5MX-2GP  [C805H58]  69.71 93.65 270 top
PC4738  SC22U6D3V5MX-2GP  [C805H58]  86.15 118.86 90 bottom
PC4739  SC22U6D3V5MX-2GP  [C805H58]  99.39 87.19 0 top
PC4740  SC22U6D3V5MX-2GP  [C805H58]  97.48 87.19 0 top
PC4741  SC22U6D3V5MX-2GP  [C805H58]  85.75 115.64 270 top
PC4742  SC22U6D3V5MX-2GP  [C805H58]  86.15 115.05 90 bottom
PC4743  SC22U6D3V5MX-2GP  [C805H58]  69.76 95.57 270 top
PC4744  SC22U6D3V5MX-2GP  [C805H58]  69.71 91.75 270 top
PC4814  SC4D7U25V5KX-GP  [C805H54]  130.63 121.99 270 top
PC4815  SC1U10V2KX-1GP  [C402H22]  126.63 123.89 0 top
PC4821  SC1KP50V2KX-1GP  [C402H22]  128.52 130.88 270 top
PC4822  SCD1U50V3KX-GP  [C603H36]  128.34 123.58 90 top
PC4823  SC18P50V2JN-1-GP  [C402H22]  126.34 130.88 0 top
PC4824  SCD1U16V2KX-3GP  [C402H22]  128.34 107.76 90 bottom
PC4825  SCD1U50V3KX-GP  [C603H36]  130.38 120.34 270 top
PC4826  SC10U25V5KX-GP  [C805H56]  130.63 121.99 90 bottom
PC4838  SC560P50V-GP  [C603]  127.2 118.56 270 bottom
PC4901  SC1U10V3KX-3GP  [C603H36]  101.62 19.14 180 top
PC4902  SCD01U50V2KX-1GP  [C402H22]  104.59 19.75 180 top
PC4903  SCD1U16V2KX-3GP  [C402H22]  105.48 19.75 180 top
PC4904  SC1U10V3KX-3GP  [C603H36]  106.75 14.6 0 bottom
PC4906  SCD1U16V2KX-3GP  [C402H22]  102.44 11 0 top
PC4909  SC4D7U25V5KX-GP  [C805H54]  96.34 15.44 0 bottom
PC4911  SC4D7U25V5KX-GP  [C805H54]  98.24 15.44 180 top
PC4912  SC10U25V5KX-GP  [C805H56]  100.15 15.44 0 bottom
PC4913  SCD1U50V3KX-GP  [C603H36]  96.59 15.44 0 top
PC4914  SC4D7U25V5KX-GP  [C805H54]  98.24 15.44 0 bottom
PC4915  SCD1U16V2KX-3GP  [C402H22]  110.18 16.71 90 top
PC4916  SC10U6D3V3MX-GP  [C603H38]  109.98 15.31 90 top
PC4917  SC10U6D3V3MX-GP  [C603H38]  109.98 13.4 90 top
PC4918  SCD22U10V2KX-1GP  [C402H22]  107.39 17.59 90 top
PC4919  SCD1U50V3KX-GP  [C603H36]  100.4 14.55 90 top
PC4920  SC4D7U6D3V3KX-GP  [C603H36]  79.47 14.5 0 top
PC4921  SCD1U16V2KX-3GP  [C402H22]  80.86 14.5 0 top
PC4922  SC330P50V2KX-3GP  [C402H22]  94.55 18.03 270 bottom
PC4923  SC22U6D3V5MX-2GP  [C805H58]  79.58 12.77 180 bottom
PC4924  SC22U6D3V5MX-2GP  [C805H58]  77.67 12.77 180 bottom
PC4925  SC22U6D3V5MX-2GP  [C805H58]  81.48 12.77 180 bottom
PC4926  SC22U6D3V5MX-2GP  [C805H58]  83.39 12.77 180 bottom
PC5101  SC22U6D3V5MX-2GP  [C805H58]  180.03 56.46 180 bottom
PC5108  SC22U6D3V5MX-2GP  [C805H58]  174.72 62.12 0 bottom
PC5109  SC1U10V2KX-1GP  [C402H22]  155.14 60.14 270 bottom
PC5110  SCD1U50V3KX-GP  [C603H36]  161.36 59.38 90 top
PC5111  SC220P50V2KX-3GP  [C402H22]  157.43 62.68 180 bottom
PC5112  SC2D2U6D3V2MX-GP  [C402H22]  154.52 62.3 0 bottom
PC5113  SC4D7U25V5KX-GP  [C805H54]  154.51 56.84 180 bottom
PC5114  SCD1U50V3KX-GP  [C603H36]  186.89 120.94 0 top
PC5115  SC4D7U25V5KX-GP  [C805H54]  156.41 56.84 180 bottom
PC5116  SC22U6D3V5MX-2GP  [C805H58]  185.24 121 0 top
PC5117  SC22U6D3V5MX-2GP  [C805H58]  191.34 139.39 90 top
PC5118  SC22U6D3V5MX-2GP  [C805H58]  172.81 62.12 0 bottom
PC5119  SC1U10V2KX-1GP  [C402H22]  120.23 109.97 180 bottom
PC5120  SC1U10V2KX-1GP  [C402H22]  114.71 110.36 0 bottom
PC8201  SCD1U16V2KX-3GP  [C402H22]  151.46 79.95 0 top
PC8202  SCD1U25V2KX-GP  [C402H22]  149.5 82.38 180 bottom
PC8203  SC1KP50V2KX-1GP  [C402H22]  152.73 78.68 0 top
PC8204  SCD01U50V2KX-1GP  [C402H22]  149.68 79.95 180 top
PC8205  SC1KP50V2KX-1GP  [C402H22]  150.34 82.37 0 bottom
PC8206  SC330P50V2KX-3GP  [C402H22]  163.62 78.81 90 bottom
PC8207  SCD1U50V3KX-GP  [C603H36]  157.93 80.48 270 bottom
PC8208  SC4D7U25V5KX-GP  [C805H54]  158.95 71.44 180 top
PC8209  SC4D7U25V5KX-GP  [C805H54]  157.05 71.44 180 top
PC8210  SC10U25V5KX-GP  [C805H56]  157.05 71.44 0 bottom
PC8211  SCD1U50V3KX-GP  [C603H36]  157.17 77.56 0 bottom
PC8212  SC4D7U25V5KX-GP  [C805H54]  157.05 88.46 0 top
PC8213  SC4D7U25V5KX-GP  [C805H54]  158.95 88.46 0 top
PC8214  SC10U25V5KX-GP  [C805H56]  158.95 71.44 0 bottom
PC8215  SC10U25V5KX-GP  [C805H56]  157.05 88.46 180 bottom
PC8216  SCD1U50V3KX-GP  [C603H36]  155.76 84.78 180 bottom
PC8217  SC47P50V2JN-3GP  [C402H22]  150.95 84.46 90 bottom
PC8218  SC330P50V2KX-3GP  [C402H22]  163.65 80.59 90 bottom
PC8219  SC47P50V2JN-3GP  [C402H22]  151.83 83.65 90 bottom
PC8220  SCD1U25V2KX-GP  [C402H22]  160.35 71.32 180 bottom
PC8221  SCD1U25V2KX-GP  [C402H22]  160.35 88.59 0 bottom
PC8222  SC47P50V2JN-3GP  [C402H22]  152.73 84.46 270 bottom
PC8223  SC5600P25V2KX-1GP  [C402H22]  148.79 79.95 180 top
PC8224  SC10U25V5KX-GP  [C805H56]  158.95 88.46 180 bottom
PC8225  SCD1U25V2KX-GP  [C402H22]  154.05 74.29 90 bottom
PC8226  SCD1U25V2KX-GP  [C402H22]  152.09 76.01 270 bottom
PC8302  SCD01U50V2KX-1GP  [C402H22]  178.9 53.1 270 bottom
PC8303  SC10U6D3V3MX-GP  [C603H38]  170.51 48.76 180 bottom
PC8307  SC10U6D3V3MX-GP  [C603H38]  178.38 56.46 180 bottom
PD4201  P6SBMJ24APT-GP  [D5436AKH97]  96.92 152.57 90 bottom
PD4203  LBAV99LT1G-1-GP  [SOT23-2D4-312H44]  111.2 143.76 270 top
PD4204  PESD24VS2UT-GP  [SOT-23-10H44]  108.02 153.27 90 top
PD4302  SMF18AT1G-GP  [SOD123FLAKH40]  136.6 148.79 90 top
PD4401  SD103AWS-1-GP  [SOD323AKH42]  108.79 138.75 180 bottom
PD4404  1N4148WS-7-F-GP  [SOD323AKH42]  140.91 137.87 180 top
PD4501  BZT52C15S-GP  [SOD323AKH42]  139.77 41.09 0 bottom
PD4502  BAT54SPT-1-GP  [SOT-23-13H51]  136.75 41.27 0 bottom
PD4503  BAT54SPT-1-GP  [SOT-23-13H51]  136.75 36.92 180 bottom
PG4402  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  92.5 141.36 0 bottom
PG4403  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  92.47 140.21 0 bottom
PG4404  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  131.39 142.94 90 bottom
PG4405  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  133.17 142.94 90 bottom
PG4407  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  99.21 137.48 180 bottom
PG4408  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  99.21 136.46 180 bottom
PG4409  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  131.39 147.26 270 bottom
PG4410  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  133.17 147.26 270 bottom
PG4411  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  104.85 139.39 90 top
PG4412  -  [GAP-CLOSE-PWR]  112.34 134.94 90 bottom
PG4413  -  [GAP-CLOSE-PWR]  114.63 134.94 90 bottom
PG4414  -  [GAP-CLOSE-PWR]  113.87 134.94 90 bottom
PG4415  -  [GAP-CLOSE-PWR]  113.1 134.94 90 bottom
PG4517  -  [GAP-CLOSE-PWR]  125.17 10.36 270 bottom
PG4518  -  [GAP-CLOSE-PWR]  140.66 30.42 0 top
PG4519  -  [GAP-CLOSE-PWR]  130.89 10.14 90 bottom
PG4520  -  [GAP-CLOSE-PWR]  140.66 31.18 0 top
PG4521  -  [GAP-CLOSE-PWR]  119.33 30.5 180 top
PG4522  -  [GAP-CLOSE-PWR]  124.41 10.36 270 bottom
PG4523  -  [GAP-CLOSE-PWR]  137.75 10.14 90 bottom
PG4524  -  [GAP-CLOSE-PWR]  119.33 31.26 180 top
PG4525  -  [GAP-CLOSE-PWR]  119.33 32.02 180 top
PG4526  -  [GAP-CLOSE-PWR]  123.64 10.36 270 bottom
PG4527  -  [GAP-CLOSE-PWR]  131.65 10.14 90 bottom
PG4528  -  [GAP-CLOSE-PWR]  122.88 10.36 270 bottom
PG4529  -  [GAP-CLOSE-PWR]  122.12 10.36 270 bottom
PG4530  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  136.22 44.14 0 bottom
PG4531  -  [GAP-CLOSE-PWR]  119.33 32.78 180 top
PG4532  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  137.59 14.8 0 bottom
PG4533  -  [GAP-CLOSE-PWR]  132.41 10.14 90 bottom
PG4534  -  [GAP-CLOSE-PWR]  140.66 31.95 0 top
PG4535  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  120.6 14.95 180 bottom
PG4536  -  [GAP-CLOSE-PWR]  140.66 32.71 0 top
PG4537  -  [GAP-CLOSE-PWR]  133.17 10.14 90 bottom
PG4538  -  [GAP-CLOSE-PWR]  133.94 10.14 90 bottom
PG4540  -  [GAP-CLOSE-PWR]  134.7 10.14 90 bottom
PG4541  -  [GAP-CLOSE-PWR]  135.46 10.14 90 bottom
PG4542  -  [GAP-CLOSE-PWR]  140.66 33.47 0 top
PG4543  -  [GAP-CLOSE-PWR]  140.66 34.23 0 top
PG4544  -  [GAP-CLOSE-PWR]  136.22 10.14 90 bottom
PG4545  -  [GAP-CLOSE-PWR]  136.98 10.14 90 bottom
PG4701  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  96.85 118.69 0 bottom
PG4702  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  92.02 118.69 180 bottom
PG4703  -  [GAP-CLOSE-PWR]  104.72 124.66 270 bottom
PG4704  -  [GAP-CLOSE-PWR]  105.48 124.66 270 bottom
PG4705  -  [GAP-CLOSE-PWR]  106.25 124.66 270 bottom
PG4706  -  [GAP-CLOSE-PWR]  107.01 124.66 270 bottom
PG4707  -  [GAP-CLOSE-PWR]  107.77 124.66 270 bottom
PG4708  -  [GAP-CLOSE-PWR]  108.53 124.66 270 bottom
PG4824  -  [GAP-CLOSE-PWR]  128.62 105.64 0 bottom
PG4825  -  [GAP-CLOSE-PWR]  128.62 104.88 0 bottom
PG4826  -  [GAP-CLOSE-PWR]  128.62 104.12 0 bottom
PG4827  -  [GAP-CLOSE-PWR]  134.57 122.37 0 top
PG4828  -  [GAP-CLOSE-PWR]  128.62 101.83 0 bottom
PG4830  -  [GAP-CLOSE-PWR]  128.62 102.59 0 bottom
PG4831  -  [GAP-CLOSE-PWR]  128.62 103.35 0 bottom
PG4832  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  133.55 104.46 180 bottom
PG4834  -  [GAP-CLOSE-PWR]  134.57 121.61 0 top
PG4837  -  [GAP-CLOSE-PWR]  134.57 120.85 0 top
PG4838  -  [GAP-CLOSE-PWR]  134.57 120.08 0 top
PG4901  -  [GAP-CLOSE-PWR]  109.55 17.98 270 top
PG4902  -  [GAP-CLOSE-PWR]  108.79 17.98 270 top
PG4903  -  [GAP-CLOSE-PWR]  97.1 11.24 270 top
PG4904  -  [GAP-CLOSE-PWR]  97.86 11.24 270 top
PG4905  -  [GAP-CLOSE-PWR]  98.63 11.24 270 top
PG4906  -  [GAP-CLOSE-PWR]  96.34 11.24 270 top
PG4907  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  76.65 13.66 0 bottom
PG4908  -  [GAP-CLOSE-PWR]  78.43 18.61 270 bottom
PG4909  -  [GAP-CLOSE-PWR]  79.19 18.61 270 bottom
PG4910  -  [GAP-CLOSE-PWR]  79.96 18.61 270 bottom
PG4911  -  [GAP-CLOSE-PWR]  79.96 18.61 270 top
PG4912  -  [GAP-CLOSE-PWR]  83 18.61 270 top
PG4913  -  [GAP-CLOSE-PWR]  83 18.61 270 bottom
PG4914  -  [GAP-CLOSE-PWR]  82.24 18.61 270 bottom
PG4915  -  [GAP-CLOSE-PWR]  81.48 18.61 270 bottom
PG4916  -  [GAP-CLOSE-PWR]  80.72 18.61 270 bottom
PG4917  -  [GAP-CLOSE-PWR]  79.19 18.61 270 top
PG4918  -  [GAP-CLOSE-PWR]  80.72 18.61 270 top
PG4919  -  [GAP-CLOSE-PWR]  81.48 18.61 270 top
PG4920  -  [GAP-CLOSE-PWR]  82.24 18.61 270 top
PG5101  -  [GAP-CLOSE-PWR]  152.86 59.08 0 bottom
PG5102  -  [GAP-CLOSE-PWR]  152.86 58.32 0 bottom
PG5103  -  [GAP-CLOSE-PWR]  152.86 57.56 0 bottom
PG5104  GAP-CLOSE-PWR-3-GP  [GAP-CLOSE-PWR-3]  175.73 61.35 180 bottom
PG5105  -  [GAP-CLOSE-PWR]  114.29 108.98 180 bottom
PG8201  -  [GAP-CLOSE-PWR]  155.39 89.35 0 top
PG8202  -  [GAP-CLOSE-PWR]  155.39 90.11 0 top
PG8203  -  [GAP-CLOSE-PWR]  155.39 90.87 0 top
PG8204  -  [GAP-CLOSE-PWR]  155.39 93.16 0 top
PG8205  -  [GAP-CLOSE-PWR]  155.39 92.4 0 top
PG8206  -  [GAP-CLOSE-PWR]  155.39 91.64 0 top
PG8207  -  [GAP-CLOSE-PWR]  156.03 67.25 0 top
PG8208  -  [GAP-CLOSE-PWR]  156.03 66.49 0 top
PG8209  -  [GAP-CLOSE-PWR]  156.03 65.73 0 top
PG8210  -  [GAP-CLOSE-PWR]  156.03 68.01 0 top
PG8211  -  [GAP-CLOSE-PWR]  156.03 68.78 0 top
PG8212  -  [GAP-CLOSE-PWR]  156.03 69.54 0 top
PG8312  -  [GAP-CLOSE-PWR]  152.1 118.13 270 top
PG8313  -  [GAP-CLOSE-PWR]  154.88 124.38 0 top
PG8314  -  [GAP-CLOSE-PWR]  154.88 123.61 0 top
PG8315  -  [GAP-CLOSE-PWR]  154.88 122.85 0 top
PL4401  IND-5D6UH-45-GP  [L686647H119]  125.8 139.26 0 bottom
PL4501  IND-2D2UH-46-GP-U  [L736630-MH119]  135.71 23.44 180 bottom
PL4502  IND-3D3UH-57GP  [L736630H119]  124.53 23.31 0 bottom
PL4701  IND-D22UH-9-GP-U  [L115100-275300H158]  94.43 118.69 90 bottom
PL4801  IND-2D2UH-46-GP-U  [L736630-MH119]  131 112.98 180 bottom
PL4902  COIL-D68UH-5-GP  [L736630H119]  89.1 14.72 90 bottom
PL5101  IND-1UH-206-GP  [L6965-1332-1H119]  166.7 58.74 270 bottom
PL8201  IND-D33UH-7-GP  [L736630H119]  174.05 72.91 270 bottom
PL8202  IND-D33UH-7-GP  [L736630H119]  174.06 86.81 270 bottom
PQ4201  DMN5L06K-7-GP  [SOT23DGS2D4H48]  113.18 146.37 270 bottom
PQ4202  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  117.07 146.04 180 bottom
PQ4203  2N7002KDW-GP  [SOT-363H44]  109.67 149.93 0 bottom
PQ4204  PDTC124EU-1-GP  [SOT323CBE2D2H44]  107.63 143.96 0 top
PQ4205  PDTA124EU-1-GP  [SOT323CBE2D2H44]  107.77 147.52 90 top
PQ4206  2N7002KDW-GP  [SOT-363H44]  109.29 153.36 90 bottom
PQ4208  2N7002K-2-GP  [SOT23DGS2D4H44]  106.8 144.31 270 bottom
PQ4402  2N7002KDW-GP  [SOT-363H44]  92.73 146.25 0 bottom
PQ4407  2N7002KDW-GP  [SOT-363H44]  97.99 132.4 270 bottom
PQ4408  2N7002KDW-GP  [SOT-363H44]  110.06 131.64 270 top
PQ4409  LMBT3906LT1G-1-GP  [SOT23CBE2D4H44]  138 138.27 180 top
PQ4410  2N7002KDW-GP  [SOT-363H44]  140.79 142.07 0 top
PQ4414  2N7002K-1-GP  [SOT23DGS2D4H44]  115.21 146.23 270 top
PQ8304  2N7002KDW-GP  [SOT-363H44]  181.43 52.39 180 bottom
PQ8305  2N7002KDW-GP  [SOT-363H44]  150.25 114.12 270 top
PQ8306  2N7002K-2-GP  [SOT23DGS2D4H44]  184.73 56.08 180 bottom
PQ8307  2N7002K-2-GP  [SOT23DGS2D4H44]  149.13 100.1 180 top
PQ8308  SIRA06DP-T1-GE3-GP  [PPAK-5PH45]  174.44 52.52 0 bottom
PR4202  15KR2F-GP  [R402H16]  110.43 149.49 270 top
PR4203  10KR2J-3-GP  [R402H16]  119.56 147.18 0 bottom
PR4204  2K2R2J-2-GP  [R402H16]  113.66 143.6 180 top
PR4205  33R2J-2-GP  [R402H16]  114.92 144.04 270 top
PR4206  33R2J-2-GP  [R402H16]  112.19 144.11 270 bottom
PR4207  240KR3-GP  [R603H22]  97.31 147.79 90 bottom
PR4208  47KR3J-L-GP  [R603H22]  95.07 145.91 180 bottom
PR4209  100KR2J-1-GP  [R402H16]  110.43 150.38 90 top
PR4210  1KR2J-1-GP  [R402H16]  107.64 150.82 180 bottom
PR4211  10KR2J-3-GP  [R402H16]  107.54 148.86 180 bottom
PR4212  100KR2J-1-GP  [R402H16]  106.17 153.73 0 bottom
PR4213  100KR2J-1-GP  [R402H16]  107 153.73 180 bottom
PR4214  3K3R6J-GP  [R1206H28]  103.33 154.05 270 bottom
PR4215  1KR2J-1-GP  [R402H16]  109.14 145.56 0 bottom
PR4216  100KR2J-1-GP  [R402H16]  109.98 145.56 180 bottom
PR4217  0R3J-0-U-GP  [R603H22]  108.35 149.82 90 top
PR4218  100KR2J-1-GP  [R402H16]  110.41 147.69 270 bottom
PR4401  10KR2F-2-GP  [R402H16]  92.53 143.58 180 bottom
PR4402  D01R3721F-GP-U  [R3720H40]  89.23 140.8 180 bottom
PR4403  100KR2J-1-GP  [R402H16]  91.64 143.58 180 bottom
PR4404  3KR5J-GP  [R805H24]  91.64 149.04 270 bottom
PR4405  470KR2J-2-GP  [R402H16]  110.89 132.94 270 bottom
PR4406  0R2J-2-GP  [R402H16]  105.1 131.64 270 top
PR4407  309KR2F-GP  [R402H16]  100.15 134.43 270 bottom
PR4408  10R5J-GP  [R805H24]  110.06 134.82 0 bottom
PR4409  0R3J-0-U-GP  [R603H22]  106.5 139.08 0 top
PR4410  6D8R2F-GP  [R402H16]  122.41 145.64 0 top
PR4411  102KR2F-GP  [R402H16]  102.93 132.67 0 bottom
PR4412  3K3R2F-2-GP  [R402H16]  98.06 136.08 0 bottom
PR4413  84K5R2F-GP  [R402H16]  104.21 136.47 180 top
PR4414  3D3MR2J-GP  [R402H16]  103.71 133.93 90 bottom
PR4415  3K3R2F-2-GP  [R402H16]  98.06 137.85 180 bottom
PR4416  D01R3721F-GP-U  [R3720H40]  132.28 145.1 270 bottom
PR4417  100KR2J-1-GP  [R402H16]  99.94 139.77 270 bottom
PR4418  -  [0R0402-PAD]  101.96 142.64 270 bottom
PR4419  100KR2J-1-GP  [R402H16]  105.1 130.37 270 bottom
PR4420  7D5R2F-GP  [R402H16]  103.58 141.37 0 bottom
PR4421  10R2F-L-GP  [R402H14]  104.47 141.37 0 bottom
PR4422  0R2J-2-GP  [R402H16]  99.9 135.32 90 bottom
PR4423  59KR2F-GP  [R402H16]  99.93 138.94 90 bottom
PR4424  8K45R2F-2-GP  [R402H16]  102.94 138.63 90 top
PR4425  100KR2J-1-GP  [R402H16]  101.17 131.26 270 bottom
PR4426  -  [0R0402-PAD]  112.29 130.95 0 top
PR4427  66K5R2F-GP  [R402H16]  103.81 132.67 0 bottom
PR4428  100KR2J-1-GP  [R402H16]  106.55 130.76 180 bottom
PR4429  150KR2F-L-GP  [R402H16]  104.72 132.68 180 bottom
PR4430  100KR2J-1-GP  [R402H16]  106.5 132.53 0 bottom
PR4431  47KR2F-GP  [R402H16]  102.94 135.96 90 top
PR4432  120KR2F-L-GP  [R402H16]  105.48 133.93 270 bottom
PR4433  120KR2F-L-GP  [R402H16]  101.93 134.43 90 bottom
PR4434  100KR2J-1-GP  [R402H16]  101.17 132.15 270 bottom
PR4435  10KR2F-2-GP  [R402H16]  100.33 141.04 0 bottom
PR4436  120KR2F-L-GP  [R402H16]  107.39 130.75 0 bottom
PR4437  160KR2F-GP  [R402H16]  107.9 133.06 270 bottom
PR4438  100KR2J-1-GP  [R402H16]  105.61 132.53 180 bottom
PR4439  10KR2F-2-GP  [R402H16]  98.98 141.52 270 bottom
PR4446  20KR2F-L-GP  [R402H16]  122.5 147.52 0 top
PR4448  0R2J-2-GP  [R402H16]  125.77 145.61 270 top
PR4452  0R2J-2-GP  [R402H16]  123.39 147.52 180 top
PR4454  10R2F-L-GP  [R402H14]  125.77 144.72 270 top
PR4464  680KR2J-GP  [R402H16]  136.63 141.38 270 top
PR4465  0R2J-2-GP  [R402H16]  143.29 138.33 270 top
PR4466  0R2J-2-GP  [R402H16]  143.29 139.15 90 top
PR4467  1MR2J-1-GP  [R402H16]  135.76 139.21 180 top
PR4468  0R2J-2-GP  [R402H16]  142.85 137.07 180 top
PR4469  100KR2J-1-GP  [R402H16]  134.44 138.32 90 top
PR4470  100KR2F-L1-GP  [R402H16]  142.57 145.67 270 top
PR4471  0R2J-2-GP  [R402H16]  143.69 137.07 0 top
PR4472  100KR2F-L1-GP  [R402H16]  111.04 147.53 180 top
PR4473  10KR2F-2-GP  [R402H16]  140.79 145.67 270 top
PR4474  100KR2J-1-GP  [R402H16]  112.76 147.52 180 top
PR4475  0R2J-2-GP  [R402H16]  138.34 141.37 90 top
PR4476  0R2J-2-GP  [R402H16]  138.33 142.2 90 top
PR4501  0R2J-2-GP  [R402H16]  125.02 42.97 90 top
PR4504  -  [0R0402-PAD]  133.25 43.24 0 top
PR4506  -  [0R0402-PAD]  125.8 39.44 90 top
PR4507  -  [0R0402-PAD]  125.55 40.71 180 top
PR4512  6K8R2F-2-GP  [R402H16]  128.22 42.11 0 top
PR4517  73K2R2F-GP  [R402H16]  126.44 40.71 180 top
PR4523  10KR2F-2-GP  [R402H16]  129.11 42.74 180 top
PR4524  1D5R3-GP  [R603H22]  135.2 36.67 90 top
PR4525  0R2J-2-GP  [R402H16]  133.27 42.11 180 bottom
PR4526  9K76R2F-1-GP  [R402H16]  132.51 43.4 270 bottom
PR4527  15K4R2F-GP  [R402H16]  131.98 42.56 90 bottom
PR4528  1D5R3-GP  [R603H22]  124.97 36.15 90 top
PR4529  2D2R5F-2-GP  [R805H24]  130.92 24.56 180 top
PR4530  0R2J-2-GP  [R402H16]  125.02 42.11 270 top
PR4531  137KR2F-1-GP  [R402H16]  129.51 39.44 180 bottom
PR4532  -  [0R0402-PAD]  129.97 42.36 180 top
PR4533  2D2R5F-2-GP  [R805H24]  129.09 24.56 180 top
PR4534  100KR2J-1-GP  [R402H16]  125.8 38.55 90 top
PR4535  0R2J-2-GP  [R402H16]  127.71 43.38 270 top
PR4601  75R2F-2-GP  [R402H16]  116.47 115.3 180 top
PR4602  499R2F-2-GP  [R402H16]  121.74 120.22 180 top
PR4603  1K27R2F-L-GP  [R402H16]  119.33 124.56 180 top
PR4604  10R2F-L-GP  [R402H14]  76.29 91.36 180 bottom
PR4606  0R2J-2-GP  [R402H16]  120.16 124.56 180 top
PR4607  124KR2F-GP  [R402H16]  111.87 122.67 90 top
PR4610  100KR2F-L1-GP  [R402H16]  118.73 119.62 270 bottom
PR4613  5K1R2F-2-GP  [R402H16]  118.73 122.41 90 bottom
PR4614  90K9R2F-GP  [R402H16]  113.81 115.3 180 top
PR4615  3K83R2F-GP  [R402H16]  121.65 121.65 270 top
PR4616  -  [0R0402-PAD]  118.25 115.3 0 top
PR4617  16KR2F-GP  [R402H16]  121.65 122.54 270 top
PR4618  -  [0R0402-PAD]  117.36 115.3 0 top
PR4619  -  [0R0402-PAD]  114.7 115.3 0 top
PR4620  54D9R2F-L1-GP  [R402H16]  119.14 115.3 0 top
PR4621  -  [0R0402-PAD]  120.89 115.78 0 top
PR4622  NTC-470K-5-GP-U  [NTC-402H22-U]  104.87 113.1 90 bottom
PR4624  -  [0R0402-PAD]  120.86 120.22 180 top
PR4628  -  [0R0402-PAD]  120.86 118.45 0 top
PR4630  130R2F-1-GP  [R402H16]  115.58 115.3 0 top
PR4701  0R3J-0-U-GP  [R603H22]  112.25 120.26 270 top
PR4702  3K65R2F-1-GP  [R402H16]  97.23 124.66 90 bottom
PR4703  4K42R2F-GP  [R402H16]  96.21 125.65 90 bottom
PR4704  NTC-10K-26-GP-U  [NTC-402H22-U]  95.32 124.72 90 bottom
PR4705  357R2F-GP  [R402H16]  116.19 124.85 0 top
PR4706  0R2J-2-GP  [R402H16]  117.08 124.85 0 top
PR4707  10MR2F-GP  [R402H16]  114.98 123.59 270 top
PR4708  11KR2F-L-GP  [R402H16]  113.52 124.86 180 top
PR4817  105KR2F-1-GP  [R402H16]  132.51 129.85 270 top
PR4819  -  [0R0402-PAD]  130.25 130.88 270 top
PR4820  2D2R3-1-U-GP  [R603H22]  131.97 123.58 270 top
PR4821  -  [0R0402-PAD]  132.51 129 90 top
PR4822  10KR2F-2-GP  [R402H16]  125.45 130.88 0 top
PR4823  21KR2F-GP  [R402H16]  125.88 129.61 270 top
PR4824  470KR2F-GP  [R402H16]  125.88 128.74 270 top
PR4837  2D2R5F-2-GP  [R805H24]  126.18 116.4 0 bottom
PR4901  30K1R2F-L-GP  [R402H16]  103.71 19.75 180 top
PR4902  133KR2F-GP  [R402H16]  106.26 10.41 0 top
PR4903  10KR2F-2-GP  [R402H16]  104.98 18.48 270 top
PR4904  20KR2F-L-GP  [R402H16]  108.4 10.99 270 top
PR4905  2D2R3-1-U-GP  [R603H22]  100.4 13.15 270 top
PR4906  -  [0R0402-PAD]  104.21 21.02 90 top
PR4907  -  [0R0402-PAD]  101.58 11 180 top
PR4908  1KR2F-3-GP  [R402H16]  107.08 10.42 180 top
PR4911  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  106.75 19.5 180 top
PR4912  2D2R5F-2-GP  [R805H24]  94.5 16.15 0 bottom
PR5102  0R3J-0-U-GP  [R603H22]  158.95 59.38 90 top
PR5103  100KR2F-L1-GP  [R402H16]  158.31 62.68 0 bottom
PR5104  1MR2J-1-GP  [R402H16]  161.49 62.68 0 bottom
PR5110  -  [0R0402-PAD]  120.65 108.58 90 bottom
PR5111  470KR2F-GP  [R402H16]  159.18 62.68 0 bottom
PR5112  0R2J-2-GP  [R402H16]  155.14 61.03 270 bottom
PR5113  150KR2F-L-GP  [R402H16]  156.54 62.68 180 bottom
PR5114  0R2J-2-GP  [R402H16]  160.6 62.68 0 bottom
PR8201  499KR2F-1-GP  [R402H16]  149.35 81.11 270 bottom
PR8202  2D2R2F-GP  [R402H16]  149.54 84.27 180 bottom
PR8203  100KR2J-1-GP  [R402H16]  154.22 86.96 180 bottom
PR8206  7K5R2F-1-GP  [R402H16]  148.89 79.84 180 bottom
PR8207  -  [0R0402-PAD]  149.82 75.03 0 bottom
PR8208  0R2J-2-GP  [R402H16]  150.27 78.78 0 bottom
PR8209  7K87R2F-GP  [R402H16]  150.57 79.95 180 top
PR8210  0R3J-0-U-GP  [R603H22]  155.27 76.4 270 bottom
PR8211  0R3J-0-U-GP  [R603H22]  154.47 84.77 0 bottom
PR8212  100R2F-L1-GP-U  [R402H14]  152.73 85.29 90 bottom
PR8213  100R2F-L1-GP-U  [R402H14]  150.95 85.29 90 bottom
PR8215  2D2R5F-2-GP  [R805H24]  167.08 80.59 90 bottom
PR8216  2D2R5F-2-GP  [R805H24]  167.08 78.68 90 bottom
PR8220  -  [0R0402-PAD]  151.46 86.56 0 bottom
PR8221  -  [0R0402-PAD]  152.35 86.56 0 bottom
PR8222  27KR2F-L-GP  [R402H16]  149.45 78.08 0 bottom
PR8223  2D2R3J-2-GP  [R603H22]  157.93 81.88 90 bottom
PR8224  8K06R2F-GP  [R402H16]  157.68 79.19 270 bottom
PR8256  1KR2J-1-GP  [R402H16]  153.11 72.63 270 bottom
PR8257  -  [0R0402-PAD]  150.82 74.74 0 bottom
PR8258  10KR2J-3-GP  [R402H16]  151.71 74.74 0 bottom
PR8259  10KR2J-3-GP  [R402H16]  152.6 74.74 180 bottom
PR8260  13KR2F-GP  [R402H16]  154.05 73.47 90 bottom
PR8301  1KR2J-1-GP  [R402H16]  147.79 120.54 90 top
PR8310  100KR2J-1-GP  [R402H16]  178.89 51.38 90 bottom
PR8311  100KR2J-1-GP  [R402H16]  183.46 53.03 0 bottom
PR8312  330KR2J-L1-GP  [R402H16]  178.9 50.54 90 bottom
PR8313  100KR2J-1-GP  [R402H16]  183.84 51.63 90 bottom
PR8314  100KR2J-1-GP  [R402H16]  185.87 53.15 0 bottom
PR8315  10R2J-2-GP  [R402H14]  182.45 56.71 180 bottom
PR8316  10R2J-2-GP  [R402H14]  149.32 112.15 90 top
PR8317  10R2J-2-GP  [R402H14]  148.94 96.89 180 top
PT4501  SE220U6D3VM-38-GP  [SE361414H178]  138.1 14.8 270 bottom
PT4502  SE220U6D3VM-38-GP  [SE361414H178]  120.09 14.95 90 bottom
PT4701  SE330U2D5VM-8-GP  [SE361416H178]  71.47 98.61 90 bottom
PT4702  SE33U25VM-10-GP  [SE361413H182]  91.36 134.89 270 bottom
PT4803  SE330U2D5VM-14-GP  [SE361414H178]  133.99 104.47 270 bottom
PT8206  SE330U2D5VM-14-GP  [SE361414H178]  184.1 77.41 270 bottom
PT8207  SE330U2D5VM-14-GP  [SE361414H178]  184.1 85.29 270 bottom
PT8208  SE330U2D5VM-14-GP  [SE361414H178]  184.1 69.54 270 bottom
PU4201  SI7121DN-T1-GE3-GP  [PPAK-8P-2H45]  89.28 152.54 270 bottom
PU4402  SI7121DN-T1-GE3-GP  [PPAK-8P-2H45]  88.97 146.2 180 bottom
PU4403  SI7121DN-T1-GE3-GP  [PPAK-8P-2H45]  138.12 143.07 180 bottom
PU4404  HPA02224RGRR-1-GP  [QFN20G3D5-G2D15H40]  104.85 137.74 0 bottom
PU4405  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  117.68 136.34 270 bottom
PU4406  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  119.2 140.91 90 bottom
PU4407  INA199A1-GP  [SC70-6H44]  120.22 145.99 270 top
PU4501  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  138.63 28.01 0 top
PU4502  SIS780DN-T1-GE3-GP  [PPAK-8P-2H45]  134.06 26.48 180 top
PU4503  TPS51225RUKR-GP  [QFN20-G1D75H32]  130.25 38.17 0 top
PU4504  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  121.23 28.01 0 top
PU4505  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  125.8 26.48 180 top
PU4601  ISL95813HRZ-GP  [QFN20G4030-G275175H40]  117.04 120.08 270 top
PU4701  FDMS3600-02-RJK0215-COLAY-GP  [PPAK-8P-G5324H44-COLAY]  104.47 119.32 0 bottom
PU4805  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  128.09 116.15 180 top
PU4806  RT8237CZQW-2-GP  [DFN10G3-G265175H32]  128.8 127.75 0 top
PU4808  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  132.53 117.67 0 top
PU4901  TPS51716RUKR-GP  [QFN20-G1D75H32]  105.23 14.55 270 top
PU4902  SIS412DN-T1-GE3-GP  [PPAK-8P-2H45]  93.93 13.4 270 top
PU4903  SIS780DN-T1-GE3-GP  [PPAK-8P-2H45]  92.4 17.98 90 top
PU5101  TLV70215DBVR-GP  [SOT-23-5H58]  117.44 109.47 270 bottom
PU5102  SY8208DQNC-GP-U  [QFN10M3-G4P-UH34]  159.58 59.13 90 bottom
PU8201  RT8812AGQW-GP  [QFN20-G1D75H32]  153.49 80.08 0 bottom
PU8202  SIRA14DP-T1-GE3-GP  [PPAK-5PH45]  163.9 68.01 90 top
PU8203  SIRA12DP-T1-GE3-GP  [PPAK-5PH45]  165.94 74.49 270 top
PU8204  SIRA14DP-T1-GE3-GP  [PPAK-5PH45]  163.9 68.01 270 bottom
PU8205  SIRA12DP-T1-GE3-GP  [PPAK-5PH45]  165.94 74.49 90 bottom
PU8206  SIRA14DP-T1-GE3-GP  [PPAK-5PH45]  163.9 91.13 90 top
PU8207  SIRA12DP-T1-GE3-GP  [PPAK-5PH45]  165.94 84.78 90 bottom
PU8208  SIRA14DP-T1-GE3-GP  [PPAK-5PH45]  163.9 91.13 270 bottom
PU8209  SIRA12DP-T1-GE3-GP  [PPAK-5PH45]  165.94 84.78 270 top
Q1201  DMN5L06K-7-GP  [SOT23DGS2D4H48]  66.81 45.98 90 top
Q1202  2N7002K-2-GP  [SOT23DGS2D4H44]  66.81 42.3 270 top
Q1701  2N7002KDW-GP  [SOT-363H44]  128.26 60.23 180 bottom
Q1801  2N7002KDW-GP  [SOT-363H44]  129.36 72.38 270 bottom
Q1901  2N7002K-2-GP  [SOT23DGS2D4H44]  120.8 59.3 0 top
Q2401  2N7002K-2-GP  [SOT23DGS2D4H44]  184.85 35.39 270 top
Q2402  DMP2130L-7-GP  [SOT23DGS2D4H48]  155.12 32.04 0 top
Q2403  2N7002K-2-GP  [SOT23DGS2D4H44]  151.52 32.05 180 top
Q2404  LMBT3906LT1G-1-GP  [SOT23CBE2D4H44]  154.6 26.64 90 top
Q2505  2N7002K-2-GP  [SOT23DGS2D4H44]  50.55 7.58 180 bottom
Q2601  2N7002KDW-GP  [SOT-363H44]  125.9 56.73 180 top
Q2602  2N7002K-2-GP  [SOT23DGS2D4H44]  156.72 21.07 90 top
Q2603  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  46 34.34 0 top
Q2901  2N7002K-2-GP  [SOT23DGS2D4H44]  21.84 7.08 270 bottom
Q3001  2N7002K-2-GP  [SOT23DGS2D4H44]  37.34 46.5 0 top
Q3002  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  34.58 62.73 180 top
Q3003  LMBT3904LT1G-GP  [SOT23CBE2D4H44]  35.06 66.49 270 top
Q3004  DMP2130L-7-GP  [SOT23DGS2D4H48]  38.3 53.03 0 top
Q3601  2N7002KDW-GP  [SOT-363H44]  113.67 9.94 0 top
Q3602  MMBT2222A-3-GP  [SOT23CBE2D4H44]  152.33 17.3 180 top
Q6103  DDTA144VCA-7-F-GP  [SOT23CBE2D4H44]  170.92 17.14 270 top
Q6104  DDTA144VCA-7-F-GP  [SOT23CBE2D4H44]  174.7 18.1 180 top
Q6201  DDTA144VCA-7-F-GP  [SOT23CBE2D4H44]  196.03 86.81 0 top
Q6202  DMN3404L-7-GP  [SOT23DGS2D4H48]  137.18 71.95 180 bottom
Q6203  DMP2130L-7-GP  [SOT23DGS2D4H48]  139.9 91 0 bottom
Q6204  2N7002KDW-GP  [SOT-363H44]  132.56 99.13 270 bottom
Q7301  2N7002K-2-GP  [SOT23DGS2D4H44]  153.36 96.79 90 top
Q7601  2N7002KDW-GP  [SOT-363H44]  191.73 115.45 90 bottom
Q7602  2N7002KDW-GP  [SOT-363H44]  185.87 104.27 270 bottom
Q7603  2N7002KDW-GP  [SOT-363H44]  192.73 109.21 90 bottom
Q7606  2N7002K-2-GP  [SOT23DGS2D4H44]  186.15 100.06 90 bottom
Q8301  2N7002K-2-GP  [SOT23DGS2D4H44]  192.03 98.02 180 bottom
Q8302  DMP2130L-7-GP  [SOT23DGS2D4H48]  192.02 101.81 180 bottom
R401  62R2J-GP  [R402H16]  73.74 87.59 270 bottom
R402  51R2J-2-GP  [R402H16]  75.26 89.48 270 top
R403  56R2J-4-GP  [R402H16]  75.51 87.45 270 bottom
R404  -  [0R0402-PAD]  113.76 57.34 180 bottom
R405  10KR2J-3-GP  [R402H16]  77.08 97.46 180 bottom
R406  51R2J-2-GP  [R402H16]  75.26 90.37 270 top
R407  200R2F-L-GP  [R402H16]  82.33 75.79 0 top
R408  121R2F-GP  [R402H16]  81.5 75.8 0 top
R409  100R2F-L1-GP-U  [R402H14]  75.74 72.1 0 bottom
R410  470R2J-2-GP  [R402H16]  112.87 57.34 0 bottom
R411  0R2J-2-GP  [R402H16]  77.21 98.71 90 bottom
R601  49D9R2F-GP  [R402H16]  69.52 82.81 90 top
R602  49D9R2F-GP  [R402H16]  109.33 67.18 180 bottom
R603  8K2R2F-1-GP  [R402H16]  111.88 97.38 180 bottom
R604  1KR2J-1-GP  [R402H16]  74.21 83.63 90 bottom
R605  1KR2J-1-GP  [R402H16]  74.21 82.81 90 bottom
R606  49D9R2F-GP  [R402H16]  104.42 84.52 180 top
R701  43R2J-GP  [R402H16]  75.45 85.57 270 bottom
R702  100R2F-L1-GP-U  [R402H14]  77.12 93.04 180 bottom
R703  75R2F-2-GP  [R402H16]  73.74 85.57 270 bottom
R704  130R2F-1-GP  [R402H16]  73.74 86.76 270 bottom
R705  150R2J-L1-GP-U  [R402H16]  70.21 87.53 270 bottom
R706  10KR2J-3-GP  [R402H16]  81.35 98.87 90 bottom
R707  100KR2F-L1-GP  [R402H16]  78.18 97.03 90 top
R709  47KR2F-GP  [R402H16]  81.35 97.1 270 bottom
R710  10KR2J-3-GP  [R402H16]  79.25 99.66 180 bottom
R711  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  105.95 80.17 180 top
R712  47KR2F-GP  [R402H16]  79.58 97.1 90 bottom
R713  100KR2F-L1-GP  [R402H16]  80.08 99.26 180 bottom
R801  24D9R2F-L-GP  [R402H16]  105.86 91.89 180 top
R901  100R2F-L1-GP-U  [R402H14]  77.11 91.36 180 bottom
R1101  0R0805-PAD-1-GP-U  [0R0805-PAD-U]  119.63 99.22 0 top
R1102  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  107.52 107.43 270 top
R1103  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  127.86 83.79 90 bottom
R1104  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  107.72 80 180 top
R1105  0R0805-PAD-1-GP-U  [0R0805-PAD-U]  117.67 99.23 0 top
R1201  -  [0R0402-PAD]  111.61 33.99 270 top
R1202  -  [0R0402-PAD]  111.61 32.21 270 top
R1204  2MR2-GP  [R402H16]  64.37 46.9 0 top
R1205  -  [0R0402-PAD]  65.71 48.57 90 top
R1206  66D5R2F-GP  [R402H16]  87.83 23.69 180 top
R1207  66D5R2F-GP  [R402H16]  89.1 23.18 90 top
R1208  220KR2J-L2-GP  [R402H16]  63.48 46.9 180 top
R1509  100KR2J-1-GP  [R402H16]  126.73 98.34 0 top
R1510  10KR2J-3-GP  [R402H16]  127.56 83.14 270 top
R1511  10KR2J-3-GP  [R402H16]  127.56 82.32 90 top
R1512  0R2J-2-GP  [R402H16]  132.53 92.52 270 bottom
R1601  3KR2F-GP  [R402H16]  102.59 97.27 180 bottom
R1602  22D6R2F-L1-GP  [R402H16]  112.16 79.05 180 top
R1701  10KR2J-3-GP  [R402H16]  124.04 79.91 90 bottom
R1702  1KR2J-1-GP  [R402H16]  124.49 60.31 180 bottom
R1703  1KR2J-1-GP  [R402H16]  134.05 83.67 90 bottom
R1704  0R2J-2-GP  [R402H16]  124.86 62.02 180 bottom
R1705  0R2J-2-GP  [R402H16]  132.4 82.98 180 bottom
R1706  -  [0R0402-PAD]  120.17 60.72 270 bottom
R1707  -  [0R0402-PAD]  120.18 61.55 90 bottom
R1708  0R2J-2-GP  [R402H16]  132.66 67 90 bottom
R1709  -  [0R0402-PAD]  127.76 97.12 180 top
R1710  0R2J-2-GP  [R402H16]  131.16 88.61 270 bottom
R1713  -  [0R0402-PAD]  129.99 87.2 90 bottom
R1714  8K2R2F-1-GP  [R402H16]  127.3 95.28 90 top
R1715  100KR2J-1-GP  [R402H16]  129.96 84.51 90 bottom
R1717  10KR2J-3-GP  [R402H16]  130.83 91.5 270 bottom
R1718  0R2J-2-GP  [R402H16]  125.76 62.02 180 bottom
R1720  330KR2J-L1-GP  [R402H16]  122.96 62.13 180 bottom
R1721  330KR2J-L1-GP  [R402H16]  121.95 62.13 180 bottom
R1724  10KR2J-3-GP  [R402H16]  127.48 84.85 90 bottom
R1725  100KR2F-L1-GP  [R402H16]  125.46 59.47 0 bottom
R1726  10KR2J-3-GP  [R402H16]  128.96 62.45 270 bottom
R1727  100KR2J-1-GP  [R402H16]  130.63 59.53 90 bottom
R1728  0R2J-2-GP  [R402H16]  130.66 57.82 270 bottom
R1729  0R2J-2-GP  [R402H16]  130.66 58.64 270 bottom
R1801  -  [0R0402-PAD]  160.22 15.29 180 top
R1802  1MR2J-1-GP  [R402H16]  103.78 100.51 270 bottom
R1803  3KR2F-GP  [R402H16]  103.42 97.26 0 bottom
R1804  0R2J-2-GP  [R402H16]  113.1 59.95 0 top
R1805  33R2J-2-GP  [R402H16]  110.31 59.95 0 top
R1806  33R2J-2-GP  [R402H16]  122.42 82.29 90 bottom
R1807  -  [0R0402-PAD]  123.7 87.72 0 top
R1808  -  [0R0402-PAD]  123.89 84.3 180 bottom
R1809  -  [0R0402-PAD]  125.26 83.07 180 bottom
R1810  -  [0R0402-PAD]  102.08 100.51 90 bottom
R1811  -  [0R0402-PAD]  124.89 85.39 0 top
R1812  -  [0R0402-PAD]  124.73 82.94 270 top
R1813  0R2J-2-GP  [R402H16]  111.58 62.65 180 top
R1901  1MR2J-1-GP  [R402H16]  117.63 62.4 180 top
R1902  10KR2J-3-GP  [R402H16]  120.95 56.96 270 top
R1903  330KR2J-L1-GP  [R402H16]  117.88 61.51 0 bottom
R1904  -  [0R0402-PAD]  113.66 97.38 0 bottom
R1905  10KR2J-3-GP  [R402H16]  125.09 98.2 0 top
R1906  3KR2F-GP  [R402H16]  112.77 97.38 0 bottom
R1907  33R2J-2-GP  [R402H16]  116.15 62.33 0 bottom
R1908  -  [0R0402-PAD]  112.98 66.26 180 top
R1909  1KR2J-1-GP  [R402H16]  111.3 66.26 180 top
R1911  -  [0R0402-PAD]  117 62.3 0 bottom
R1912  33R2J-2-GP  [R402H16]  112.14 66.26 180 top
R1913  330KR2J-L1-GP  [R402H16]  118.29 62.78 270 bottom
R1915  10MR2J-L-GP  [R402H16]  121.14 65.72 180 bottom
R1916  51R2J-2-GP  [R402H16]  74.21 81.98 90 bottom
R1917  51R2J-2-GP  [R402H16]  74.22 78.68 90 bottom
R1918  51R2J-2-GP  [R402H16]  74.22 81.16 90 bottom
R1919  1KR2J-1-GP  [R402H16]  74.22 80.33 90 bottom
R1920  51R2J-2-GP  [R402H16]  74.22 79.5 270 bottom
R2001  0R0402-PAD-1-GP  [0R0402-PAD]  123.1 66.75 270 top
R2002  0R0402-PAD-1-GP  [0R0402-PAD]  125.44 67.15 180 top
R2003  49D9R2F-GP  [R402H16]  108.38 67.17 180 bottom
R2004  0R0402-PAD-1-GP  [0R0402-PAD]  132.79 66.76 270 top
R2005  10KR2J-3-GP  [R402H16]  123.52 86 180 bottom
R2006  1KR2J-1-GP  [R402H16]  123.39 87.57 90 bottom
R2007  100KR2J-1-GP  [R402H16]  124.48 96.33 90 bottom
R2008  10KR2J-3-GP  [R402H16]  124.33 86 0 bottom
R2009  0R0402-PAD-1-GP  [0R0402-PAD]  124.26 68.87 270 top
R2010  10KR2J-3-GP  [R402H16]  129.95 67.8 90 top
R2011  1KR2J-1-GP  [R402H16]  123.21 96.79 0 bottom
R2012  1KR2J-1-GP  [R402H16]  110.7 82.51 0 top
R2013  10KR2J-3-GP  [R402H16]  134.28 68.08 90 top
R2014  1KR2J-1-GP  [R402H16]  127.48 85.74 90 bottom
R2015  10KR2J-3-GP  [R402H16]  128.07 66.92 90 top
R2016  0R0402-PAD-1-GP  [0R0402-PAD]  126.26 67.15 180 top
R2017  0R0402-PAD-1-GP  [0R0402-PAD]  133 68.04 180 top
R2018  1KR2J-1-GP  [R402H16]  77.11 95.76 180 bottom
R2020  0R0402-PAD-1-GP  [0R0402-PAD]  127.4 69.26 0 bottom
R2022  0R0402-PAD-1-GP  [0R0402-PAD]  128.7 69.56 270 bottom
R2023  10KR2J-3-GP  [R402H16]  134.24 92.6 270 bottom
R2024  10KR2J-3-GP  [R402H16]  134.24 91.79 90 bottom
R2025  10KR2J-3-GP  [R402H16]  127.56 80.69 270 top
R2026  10KR2J-3-GP  [R402H16]  127.56 81.5 90 top
R2027  0R2J-2-GP  [R402H16]  76.26 93.81 180 bottom
R2028  -  [0R0402-PAD]  131.65 68.14 270 top
R2029  -  [0R0402-PAD]  133.09 69.3 270 top
R2030  0R2J-2-GP  [R402H16]  134.54 66.75 270 top
R2031  0R2J-2-GP  [R402H16]  129.76 66.91 270 top
R2101  -  [0R0402-PAD]  121.03 64.56 270 top
R2102  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  114.25 59.7 0 top
R2103  -  [0R0402-PAD]  119.28 91.1 90 top
R2105  -  [0R0402-PAD]  122.21 100.01 0 top
R2108  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  109.17 60.14 180 top
R2110  5D1R2F-GP  [R402H16]  107.11 75.48 0 top
R2112  -  [0R0402-PAD]  129.89 88.46 180 bottom
R2114  0R5J-5-GP  [R805H24]  124.41 105.99 0 bottom
R2117  -  [0R0402-PAD]  116.28 102.56 0 top
R2118  -  [0R0402-PAD]  105.21 107.6 0 top
R2122  0R5J-5-GP  [R805H24]  126.31 105.99 0 bottom
R2123  0R2J-2-GP  [R402H16]  124.48 97.22 90 bottom
R2401  -  [0R0402-PAD]  181.69 29.86 270 top
R2402  0R0603-PAD-1-GP-U  [0R0603-PAD-U]  167.67 16.68 90 top
R2403  2D2R3-1-U-GP  [R603H22]  168.52 27.81 0 bottom
R2404  64K9R2F-1-GP  [R402H16]  162.88 19.28 90 top
R2405  10KR2F-2-GP  [R402H16]  160.77 19.78 0 top
R2406  100KR2F-L1-GP  [R402H16]  165.31 19.72 90 top
R2407  100KR2F-L1-GP  [R402H16]  159.41 22.61 0 top
R2408  0R0402-PAD-1-GP  [0R0402-PAD]  182.87 38.42 90 top
R2409  0R0402-PAD-1-GP  [0R0402-PAD]  181.68 26.52 90 top
R2410  0R0402-PAD-1-GP  [0R0402-PAD]  172.77 21.96 90 bottom
R2411  0R2J-2-GP  [R402H16]  173.81 26.74 180 bottom
R2412  100KR2J-1-GP  [R402H16]  151.2 8.58 270 bottom
R2413  100KR2J-1-GP  [R402H16]  157.6 33.83 0 top
R2414  10KR2J-3-GP  [R402H16]  158.67 30.09 270 top
R2415  10KR2J-3-GP  [R402H16]  179.89 39.72 180 top
R2416  -  [0R0402-PAD]  177.25 27.02 0 bottom
R2417  -  [0R0402-PAD]  182.42 37.05 0 top
R2418  10KR2J-3-GP  [R402H16]  157.76 27.25 180 top
R2419  33R2J-2-GP  [R402H16]  158.07 24.17 90 top
R2420  33R2J-2-GP  [R402H16]  158.07 23.28 90 top
R2421  100KR2J-1-GP  [R402H16]  173.96 31.52 90 bottom
R2422  33R2J-2-GP  [R402H16]  158.07 25.06 90 top
R2423  33R2J-2-GP  [R402H16]  158.08 25.96 90 top
R2424  0R2J-2-GP  [R402H16]  156.92 27.26 180 top
R2425  330KR2J-L1-GP  [R402H16]  162.48 26.33 90 bottom
R2426  100KR2J-1-GP  [R402H16]  160.22 38.35 90 bottom
R2427  -  [0R0402-PAD]  165.13 26.31 90 bottom
R2428  -  [0R0402-PAD]  168.91 24.83 90 bottom
R2429  43R2J-GP  [R402H16]  184.95 31.56 180 top
R2430  -  [0R0402-PAD]  158.47 33.83 0 top
R2431  330KR2J-L1-GP  [R402H16]  154.48 28.87 90 top
R2432  1KR2J-1-GP  [R402H16]  151.33 29.28 0 top
R2433  20KR2F-L-GP  [R402H16]  152.17 29.29 180 top
R2434  0R2J-2-GP  [R402H16]  167.43 26.54 180 bottom
R2435  -  [0R0402-PAD]  166.65 19.27 180 top
R2436  10KR2J-3-GP  [R402H16]  167.41 28.28 0 bottom
R2437  0R2J-2-GP  [R402H16]  166.85 44.14 0 top
R2438  0R2J-2-GP  [R402H16]  182.44 35.32 0 top
R2439  10KR2J-3-GP  [R402H16]  154.25 24.38 90 top
R2440  -  [0R0402-PAD]  187.2 35.69 180 top
R2441  -  [0R0402-PAD]  169.19 32.68 270 bottom
R2442  100KR2J-1-GP  [R402H16]  181.55 35.33 180 top
R2443  10KR2J-3-GP  [R402H16]  183.93 24.86 0 top
R2444  -  [0R0402-PAD]  181.69 28.2 270 top
R2445  57K6R2F-GP  [R402H16]  159.85 21.36 270 top
R2446  64K9R2F-1-GP  [R402H16]  161.61 19.78 0 top
R2447  100KR2J-1-GP  [R402H16]  181.69 27.38 90 top
R2448  0R2J-2-GP  [R402H16]  178.24 20.24 270 top
R2449  1KR2J-1-GP  [R402H16]  161.82 35.96 90 bottom
R2450  0R2J-2-GP  [R402H16]  180.61 33.88 0 top
R2451  0R2J-2-GP  [R402H16]  170.36 26.03 90 bottom
R2452  1KR2J-1-GP  [R402H16]  175.97 37.91 180 bottom
R2453  10KR2J-3-GP  [R402H16]  178.25 19.37 270 top
