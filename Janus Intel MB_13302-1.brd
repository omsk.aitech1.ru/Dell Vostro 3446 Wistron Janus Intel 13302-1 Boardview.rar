# Allegro board Janus Intel MB_13302-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A14: length 61.3
  TOP w0.216: v1(76.95,24.82) 76.8,24.82 v2(76.48,25.14)
  L4 w0.089: v1(93.75,69.44) 94.02,69.16 94.02,68.58 90.53,65.08 90.53,64.81
  L4 w0.216: v1(76.95,24.82) 76.89,24.82 75.78,25.93 75.78,27.08 74.21,28.65 74.21,30.69 73.24,31.65 73.24,34.44 75.6,36.8 75.6,39.52 90.53,54.44 90.53,64.81
  BOTTOM w0.089: v1(93.75,69.44) 93.03,70.15 93.03,72.1 CPU1.AV42
  BOTTOM w0.216: v1(76.95,24.82) 76.89,24.82 76.35,24.27 DM1.80
M_A_A15: length 61.4
  TOP w0.216: v1(75.15,26.09) 74.62,26.09 v2(74.57,26.03)
  L4 w0.089: v1(93.62,68.79) 89.95,65.12 89.95,64.81
  L4 w0.216: v1(75.15,26.09) 75.09,26.09 73.61,27.57 73.61,30.48 72.67,31.41 72.67,34.68 75.03,37.04 75.03,39.76 89.95,54.68 89.95,64.81
  BOTTOM w0.089: v1(93.62,68.79) 92.86,69.56 92.86,72.44 93.27,72.85 CPU1.AU42
  BOTTOM w0.216: v1(75.15,26.09) 75.21,26.09 75.75,25.54 75.75,22.93 DM1.78
M_A_B_DIMM_ODT: length 68.6
  TOP w0.508: Q1202.S 64.17,41.32 v2(63.4,40.55) 61.92,39.07 61.92,33.45 59.93,31.45 54.26,31.45 53.56,30.75 53.56,27.2 52.67,26.32 52.67,23.54 53.32,22.9 64.55,22.9 66.64,20.81 v3(66.64,20.5) ; v1(88.86,24.18) 88.66,23.98 R1207.1 87.89,23.18 R1206.1
  L3 w0.508: v1(88.86,24.18) 88.22,23.55 69.69,23.55 v3(66.64,20.5)
M_A_BS0: length 60.6
  TOP w0.216: v1(84.81,28.19) 84.99,28.19 v2(85.29,27.88)
  L4 w0.216: v1(98.47,67.88) 98.55,67.96 99.41,67.96 100.08,67.3 100.08,46.58 96.45,42.95 96.45,42.65 96.98,42.12 96.98,41.81 96.67,41.5 96.37,41.5 95.84,42.03 95.53,42.03 95.22,41.73 95.22,41.42 95.75,40.89 95.75,40.59 92.43,37.26 90.83,37.26 86.3,32.73 86.3,31.95 85.51,31.15 85.51,28.24 85.3,28.03 84.96,28.03 v1(84.81,28.19)
  BOTTOM w0.089: v1(98.47,67.88) 97.58,68.78 97.58,72.29 97.76,72.46 97.76,72.61 98,72.85 CPU1.AU35
  BOTTOM w0.216: v1(84.81,28.19) 84.94,28.19 85.37,28.62 85.37,29.72 85.05,30.04 DM1.109
M_A_BS1: length 61
  TOP w0.216: v1(85.35,25.45) 85.5,25.45 v2(85.82,25.77)
  L4 w0.216: v1(98.47,68.53) 98.61,68.67 99.51,68.67 100.65,67.54 100.65,46.34 97.55,43.25 97.55,41.57 92.66,36.69 91.07,36.69 86.87,32.5 86.87,31.71 86.09,30.93 86.09,27.79 85.87,27.58 85.66,27.58 85.44,27.36 85.44,26.93 85.66,26.71 85.87,26.71 86.09,26.5 86.09,25.75 85.79,25.45 v1(85.35,25.45)
  BOTTOM w0.089: v1(98.47,68.53) 97.76,69.25 97.76,71.96 97.77,71.97 97.77,72.11 CPU1.AV35
  BOTTOM w0.216: DM1.108 84.75,24.91 85.29,25.45 v1(85.35,25.45)
M_A_BS2: length 58.2
  TOP w0.216: v2(72.92,28.26) 72.92,28.27 72.59,28.6 v1(72.46,28.6)
  L4 w0.089: 89.38,64.81 89.38,65.16 93.34,69.12 93.34,69.68 v1(93.75,70.09)
  L4 w0.216: 89.38,64.81 89.38,54.92 74.46,39.99 74.46,37.28 72.1,34.92 72.1,31.18 73.03,30.24 73.03,28.71 72.84,28.52 72.54,28.52 v1(72.46,28.6)
  BOTTOM w0.216: CPU1.AY41 94.19,71.04 94.19,70.53 v1(93.75,70.09) ; DM1.79 76.05,30.12 74.53,28.6 v1(72.46,28.6)
M_A_CAS#: length 60.6
  TOP w0.216: v1(88.41,28.19) 88.23,28.19 v2(87.92,27.88)
  L4 w0.216: v1(98.47,72.74) 98.64,72.74 100.17,71.21 101.18,71.21 101.98,70.41 101.98,69.63 102.36,69.25 102.36,45.63 100.51,43.77 100.51,43.15 100.89,42.77 100.89,42.48 100.56,42.16 100.26,42.16 100.05,42.37 99.76,42.37 99.43,42.05 99.43,41.76 99.64,41.55 99.64,41.24 93.37,34.97 91.86,34.97 90.29,33.41 90.29,31.89 89.67,31.27 89.05,31.27 87.83,30.05 87.83,28.69 88.34,28.19 v1(88.41,28.19)
  BOTTOM w0.216: DM1.115 86.85,29.17 87.83,28.19 v1(88.41,28.19) ; v1(98.47,72.74) 98.62,72.74 CPU1.AU34
M_A_DIMA_CKE0: length 60.3
  TOP w0.216: v1(72.46,29.87) v2(72.46,30.49)
  L4 w0.089: 88.81,64.81 88.81,65.03 93.04,69.26 93.04,72.14 92.49,72.69 v1(92.16,72.69)
  L4 w0.216: 88.81,64.81 88.81,55.19 73.08,39.46 73.08,39.16 73.86,38.38 73.86,38.09 73.53,37.76 73.25,37.76 72.48,38.53 72.19,38.53 71.87,38.21 71.87,37.92 72.8,36.99 72.8,36.7 72.47,36.37 71.84,36.37 71.53,36.07 71.53,30.68 72.34,29.87 v1(72.46,29.87)
  BOTTOM w0.216: v1(72.46,29.87) 73.99,29.87 74.25,30.12 DM1.73 ; v1(92.16,72.69) 92.16,72.71 92.48,73.04 CPU1.AU43
M_A_DIMA_CKE1: length 60.6
  TOP w0.216: v2(74.29,24.76) 74.35,24.82 v1(74.88,24.82)
  L4 w0.089: v1(92.17,71.42) 92.46,71.13 92.46,69.19 88.24,64.97 88.24,64.81
  L4 w0.216: 88.24,64.81 88.24,55.43 70.96,38.15 70.96,30.44 71.87,29.53 71.87,28.03 74.88,25.03 v1(74.88,24.82)
  BOTTOM w0.216: v1(92.17,71.42) 92.26,71.42 CPU1.AW43 ; v1(74.88,24.82) 74.88,24.54 74.55,24.22 DM1.74
M_A_DIMA_CLK_DDR0: length 63.1
  TOP w0.127: v1(97.04,68.8) 96.85,68.8 v2(96.49,68.44)
  L4 w0.089: v1(97.04,68.8) 97.44,68.4 97.44,66.97 97.37,66.9 97.37,66.43 97.39,66.41 97.39,66.39
  L4 w0.114: 97.39,66.39 97.39,66.09 98.18,65.3 98.18,48.55 97.85,48.22 97.85,48.06 98.06,47.84 98.06,47.47 97.74,47.15 97.37,47.15 97.16,47.36 97,47.36 92.34,42.71 92.34,42.55 92.57,42.32 92.57,41.92 92.28,41.63 91.87,41.63 91.65,41.86 91.49,41.86 91.19,41.55 91.19,41.39 91.44,41.14 91.44,40.79 91.1,40.45 90.75,40.45 90.49,40.7 90.33,40.7 90.13,40.49 90.13,40.33 90.38,40.08 90.38,39.73 90.04,39.38 89.69,39.38 89.43,39.64 89.27,39.64 89.07,39.43 89.07,39.27 89.32,39.02 89.32,38.67 88.98,38.32 88.63,38.32 88.37,38.58 88.21,38.58 88.01,38.37 88.01,38.21 88.26,37.96 88.26,37.61 87.92,37.26 87.57,37.26 87.31,37.52 87.15,37.52 86.94,37.31 86.94,37.15 87.2,36.9 87.2,36.54 86.86,36.2 86.51,36.2 86.25,36.46 86.09,36.46 85.88,36.25 85.88,36.09 86.14,35.84 86.14,35.48 85.8,35.14 85.45,35.14 85.19,35.4 85.03,35.4 84.82,35.19 84.82,35.03 85.08,34.77 85.08,34.42 84.74,34.08 84.39,34.08 84.13,34.34 83.97,34.34 83.7,34.07 83.7,33.01 83.46,32.77 83.46,30.29 83.57,30.18 83.57,29.26 v1(83.13,28.82)
  BOTTOM w0.089: CPU1.AV37 96.18,72.1 96.18,70.9 96.2,70.89 96.2,70.87
  BOTTOM w0.102: 96.2,70.87 96.2,70.62 96.02,70.44 96.02,69.82 v1(97.04,68.8)
  BOTTOM w0.127: DM1.101 82.65,29.31 v1(83.13,28.82)
M_A_DIMA_CLK_DDR1: length 62.1
  TOP w0.127: v2(84.15,24.99) 83.92,24.76 83.61,24.76 v1(83.55,24.82)
  L4 w0.089: 98.08,66.67 98.1,66.69 98.1,66.85 97.69,67.27 97.69,69.2 97.57,69.31 97.57,70.85 97.47,70.95 97.09,70.95 v1(96.9,70.76)
  L4 w0.114: 98.08,66.67 98.08,66.22 98.7,65.6 98.7,47.31 97.52,46.12 97.36,46.12 97.1,46.38 96.75,46.38 96.41,46.04 96.41,45.69 96.66,45.43 96.66,45.27 96.46,45.06 96.3,45.06 96.04,45.32 95.69,45.32 95.35,44.98 95.35,44.63 95.6,44.37 95.6,44.21 95.4,44 95.23,44 94.98,44.26 94.63,44.26 94.29,43.92 94.29,43.56 94.54,43.31 94.54,43.15 94.34,42.94 94.17,42.94 93.93,43.18 93.56,43.18 93.24,42.86 93.24,42.49 93.48,42.25 93.48,42.09 84.33,32.94 84.33,32.14 84.14,31.95 84.14,29.09 84.01,28.97 84.01,27.62 83.89,27.51 83.68,27.51 83.43,27.26 83.43,26.78 83.68,26.53 83.89,26.53 84.01,26.41 84.01,25.04 83.79,24.82 v1(83.55,24.82)
  BOTTOM w0.127: v1(96.9,70.76) 97.22,71.09 CPU1.AY36 ; v1(83.55,24.82) 82.95,24.22 82.95,22.72 DM1.102
M_A_DIMA_CLK_DDR#0: length 63.4
  TOP w0.127: v1(83.13,29.46) v2(83.13,30.09)
  L4 w0.089: v1(97.04,68.15) 97.12,68.15 97.25,68.03 97.25,67.05 97.18,66.98 97.18,66.43 97.16,66.41 97.16,66.39
  L4 w0.114: v1(83.13,29.46) 83.22,29.46 83.34,29.59 83.34,30.09 83.23,30.2 83.23,32.86 83.47,33.11 83.47,34.16 83.88,34.57 84.23,34.57 84.48,34.31 84.64,34.31 84.85,34.52 84.85,34.68 84.6,34.94 84.6,35.29 84.94,35.63 85.29,35.63 85.54,35.37 85.7,35.37 85.91,35.58 85.91,35.74 85.66,36 85.66,36.35 86,36.69 86.35,36.69 86.6,36.43 86.76,36.43 86.97,36.64 86.97,36.8 86.72,37.06 86.72,37.41 87.06,37.75 87.41,37.75 87.66,37.49 87.83,37.49 88.03,37.7 88.03,37.86 87.78,38.12 87.78,38.47 88.12,38.81 88.47,38.81 88.72,38.55 88.89,38.55 89.09,38.76 89.09,38.92 88.84,39.18 88.84,39.53 89.18,39.87 89.53,39.87 89.78,39.61 89.95,39.61 90.15,39.82 90.15,39.98 89.9,40.24 89.9,40.59 90.24,40.93 90.59,40.93 90.84,40.67 91.01,40.67 91.21,40.88 91.21,41.04 90.96,41.3 90.96,41.65 91.39,42.08 91.74,42.08 91.97,41.86 92.18,41.86 92.34,42.01 92.34,42.23 92.11,42.45 92.11,42.8 96.9,47.59 97.25,47.59 97.47,47.38 97.65,47.38 97.84,47.57 97.84,47.75 97.62,47.96 97.62,48.31 97.96,48.65 97.96,65.21 97.16,66 97.16,66.39
  BOTTOM w0.089: 95.99,70.87 95.99,70.89 96.01,70.9 96.01,72.17 96.18,72.35 96.18,72.52 96.42,72.76 CPU1.AU37
  BOTTOM w0.102: v1(97.04,68.15) 97.04,67.97 96.91,67.84 96.61,67.84 96.52,67.93 96.52,69.04 95.82,69.74 95.82,70.52 95.99,70.7 95.99,70.87
  BOTTOM w0.127: DM1.103 83.25,30.17 82.89,29.81 82.89,29.57 83,29.46 v1(83.13,29.46)
M_A_DIMA_CLK_DDR#1: length 62
  TOP w0.127: v1(83.55,24.18) v2(83.55,23.61)
  L4 w0.089: v1(96.9,71.41) 97.17,71.14 97.55,71.14 97.76,70.93 97.76,69.39 97.88,69.28 97.88,67.35 98.29,66.93 98.29,66.69 98.31,66.67
  L4 w0.114: 98.31,66.67 98.31,66.32 98.93,65.69 98.93,47.22 97.61,45.9 97.26,45.9 97.01,46.15 96.85,46.15 96.64,45.94 96.64,45.78 96.89,45.53 96.89,45.18 96.55,44.84 96.2,44.84 95.95,45.09 95.79,45.09 95.58,44.88 95.58,44.72 95.83,44.47 95.83,44.12 95.49,43.77 95.14,43.77 94.89,44.03 94.72,44.03 94.52,43.82 94.52,43.66 94.77,43.41 94.77,43.05 94.43,42.71 94.08,42.71 93.84,42.95 93.66,42.95 93.47,42.77 93.47,42.59 93.71,42.35 93.71,41.99 84.56,32.84 84.56,32.05 84.36,31.85 84.36,29 84.24,28.87 84.24,27.53 83.99,27.28 83.78,27.28 83.66,27.16 83.66,26.87 83.78,26.76 83.99,26.76 84.24,26.51 84.24,24.94 83.99,24.69 83.99,24.62 v1(83.55,24.18)
  BOTTOM w0.127: v1(96.9,71.41) 97.22,71.74 CPU1.AW36 ; DM1.104 v1(83.55,24.18)
M_A_DIMA_CS#0: length 63.7
  TOP w0.216: v2(87.7,25.21) 87.47,25.45 v1(87.15,25.45)
  L4 w0.216: v1(87.15,25.45) 87.8,25.45 88.98,26.63 88.98,29.58 89.35,29.95 89.97,29.95 92.27,32.25 92.27,32.84 92.55,33.13 93.15,33.13 103.53,43.51 103.53,70.49 101.67,72.35 101.03,72.35 98.83,74.55 v1(98.74,74.55)
  BOTTOM w0.216: DM1.114 86.55,25.04 86.96,25.45 v1(87.15,25.45) ; v1(98.74,74.55) 98.88,74.55 CPU1.AP33
M_A_DIMA_CS#1: length 62.8
  TOP w0.216: v2(100.12,74.77) 99.9,74.55 v1(99.58,74.55)
  L4 w0.216: v1(99.58,74.55) 99.66,74.46 99.73,74.46 101.27,72.92 101.91,72.92 104.1,70.73 104.1,43.28 94.59,33.76 94.59,33.45 95.04,33 95.04,32.7 94.73,32.39 94.42,32.39 93.97,32.84 93.67,32.84 93.36,32.53 93.36,32.23 93.81,31.78 93.81,31.47 93.5,31.17 93.2,31.17 92.75,31.62 92.44,31.62 92.14,31.31 92.14,31 92.59,30.55 92.59,30.25 92.28,29.94 91.97,29.94 91.52,30.39 91.22,30.39 89.65,28.82 v1(89.55,28.82)
  BOTTOM w0.216: v1(89.55,28.82) 89.49,28.82 88.98,29.34 88.98,29.7 88.65,30.02 DM1.121 ; CPU1.AR32 99.72,74.55 v1(99.58,74.55)
M_A_DIMA_ODT0: length 3.1
  TOP w0.254: R1206.2 87.2,24.13 v1(87.15,24.18) 86.71,23.74 v2(86.71,23.39)
  BOTTOM w0.216: DM1.116 87.15,22.72 v1(87.15,24.18)
M_A_DIMA_ODT1: length 4.6
  TOP w0.254: v1(88.86,24.82) 89.32,24.82 v2(89.46,24.68) 89.51,24.63 89.51,23.46 89.55,23.42 R1207.2
  BOTTOM w0.254: DM1.120 88.35,22.72 88.35,24.46 88.7,24.82 v1(88.86,24.82)
M_A_DQ0: length 82
  TOP w0.14: v2(91.53,29.13) 91.2,29.46 v1(91.05,29.46)
  L3 w0.127: v1(91.05,29.46) 91.05,34.02 66.92,58.15 66.92,65.05 66.8,65.18 66.54,65.18 66.42,65.05 66.42,61.41 66.29,61.29 66.03,61.29 65.91,61.41 65.91,74.72 68.21,77.03 72.16,77.03 73.59,78.45 74.04,78.45 77.38,78.45 v1(77.55,78.62)
  BOTTOM w0.089: CPU1.AH63 80.24,78.41 80.21,78.41 80.13,78.33 77.85,78.33 v1(77.55,78.62)
  BOTTOM w0.14: DM1.129 v1(91.05,29.46)
M_A_DQ1: length 82.6
  TOP w0.14: v1(91.05,28.19) 91.2,28.19 v2(91.53,27.86)
  L3 w0.127: v1(91.05,28.19) 90.55,28.69 90.55,33.97 66.53,57.98 66.53,60.74 66.4,60.87 66.15,60.87 66.02,60.74 66.02,59.04 65.9,58.91 65.64,58.91 65.51,59.04 65.51,74.89 68.05,77.42 72,77.42 73.42,78.85 73.88,78.85 73.88,78.85 76.77,78.85 76.99,79.07 77.74,79.07 78.06,78.75 v1(78.17,78.75)
  BOTTOM w0.089: v1(78.17,78.75) 78.42,78.51 79.65,78.51 79.95,78.64 79.96,78.64 80.18,78.72 80.32,78.72 80.39,78.69 80.53,78.64 80.53,78.64 80.68,78.55 CPU1.AH62
  BOTTOM w0.14: DM1.131 91.65,28.64 91.2,28.19 v1(91.05,28.19)
M_A_DQ2: length 81
  TOP w0.14: v1(95.25,28.19) 95.1,28.19 v2(94.77,28.52)
  L3 w0.127: v1(95.25,28.19) 94.51,28.93 94.51,34.05 69.87,58.68 69.87,58.86 70.05,59.04 70.23,59.04 73.67,55.6 73.85,55.6 74.03,55.78 74.03,55.96 69.87,60.12 69.87,67.59 73.47,71.19 73.47,74.34 75.7,76.58 76.53,76.58 77.19,77.24 v1(77.19,77.5)
  BOTTOM w0.089: v1(77.19,77.5) 77.92,76.77 79.58,76.77 79.82,77 80.19,77 CPU1.AK63
  BOTTOM w0.14: v1(95.25,28.19) 95.12,28.32 95.04,28.32 94.65,28.71 DM1.141
M_A_DQ3: length 81.6
  TOP w0.14: v1(93.75,24.82) 93.9,24.82 v2(94.23,25.14)
  L3 w0.127: v1(93.75,24.82) 93.75,24.82 94.07,24.82 94.19,24.95 94.19,25.29 94.32,25.42 95.02,25.42 95.15,25.55 95.15,25.8 95.02,25.93 94.32,25.93 94.19,26.06 94.19,26.31 94.32,26.44 95.02,26.44 95.15,26.57 95.15,26.82 95.02,26.95 94.32,26.95 94.11,27.15 94.11,33.89 69.48,58.52 69.48,59.24 69.35,59.37 69.13,59.37 69.01,59.5 69.01,59.75 69.13,59.88 69.35,59.88 69.48,60.01 69.48,60.26 69.35,60.39 69.13,60.39 69.01,60.51 69.01,60.77 69.13,60.9 69.35,60.9 69.48,61.02 69.48,61.28 69.35,61.4 69.13,61.4 69.01,61.53 69.01,61.79 69.13,61.91 69.35,61.91 69.48,62.04 69.48,62.29 69.35,62.42 69.13,62.42 69.01,62.55 69.01,62.8 69.13,62.93 69.35,62.93 69.48,63.06 69.48,63.31 69.35,63.44 69.13,63.44 69.01,63.56 69.01,63.82 69.13,63.95 69.35,63.95 69.48,64.07 69.48,64.33 69.35,64.45 69.13,64.45 69.01,64.58 69.01,64.84 69.13,64.96 69.35,64.96 69.48,65.09 69.48,67.75 73.08,71.35 73.08,74.51 75.54,76.97 76.22,76.97 76.56,77.31 v1(76.56,77.51)
  BOTTOM w0.089: CPU1.AK62 80.64,76.81 79.88,76.81 79.66,76.59 77.68,76.59 77.38,76.89 77.18,76.89 v1(76.56,77.51)
  BOTTOM w0.14: v1(93.75,24.82) 93.82,24.82 94.35,24.29 DM1.140
M_A_DQ4: length 82.8
  TOP w0.14: v1(91.95,24.18) 92.1,24.18 v2(92.43,23.85)
  L3 w0.127: v1(91.95,24.18) 91.95,24.19 91.51,24.63 91.51,25.27 91.11,25.66 91.11,26.86 90.15,27.82 90.15,33.8 65.12,58.84 65.12,75.05 67.89,77.82 71.82,77.82 73.24,79.24 73.72,79.24 76.61,79.24 76.83,79.46 77.9,79.46 78.17,79.2 78.64,79.2 v1(78.83,79.01)
  BOTTOM w0.089: v1(78.83,79.01) 79.12,78.71 79.61,78.71 79.9,78.81 80.15,78.9 80.35,78.9 80.46,78.86 80.58,78.81 81.19,78.81 CPU1.AH61
  BOTTOM w0.14: DM1.132 v1(91.95,24.18)
M_A_DQ5: length 83.8
  TOP w0.14: v2(92.43,25.78) 92.1,25.45 v1(91.95,25.45)
  L3 w0.127: v1(91.95,25.45) 91.95,25.46 91.51,25.9 91.51,26.54 91.63,26.67 92,26.67 92.12,26.8 92.12,27.05 92,27.18 91.63,27.18 91.51,27.3 91.51,27.56 91.63,27.69 91.91,27.69 92.04,27.81 92.04,28.07 91.91,28.19 91.63,28.19 91.51,28.32 91.51,34.12 67.32,58.31 67.32,65.32 66.3,66.33 66.3,74.56 68.38,76.64 72.32,76.64 73.74,78.05 77.94,78.05 v1(78.46,77.52)
  BOTTOM w0.089: v1(78.46,77.52) 78.86,77.13 79.44,77.13 79.68,77.37 79.87,77.48 80.11,77.55 80.36,77.55 80.48,77.5 80.54,77.47 80.65,77.47 80.77,77.53 80.81,77.55 81.01,77.55 81.14,77.5 81.19,77.47 81.34,77.47 81.34,77.48 81.79,77.48 81.81,77.46 82.02,77.46 82.22,77.66 CPU1.AH60
  BOTTOM w0.14: v1(91.95,25.45) 91.83,25.33 91.83,25.33 91.35,24.85 DM1.130
M_A_DQ6: length 81.9
  TOP w0.14: v1(95.25,29.46) v2(95.25,30.02)
  L3 w0.127: v1(77.83,77.52) 77.83,77.32 76.69,76.18 75.87,76.18 73.86,74.17 73.86,71.01 70.26,67.41 70.26,60.29 79.41,51.14 79.41,50.97 79.23,50.79 79.05,50.79 74.5,55.33 74.32,55.33 74.14,55.15 74.14,54.97 94.9,34.21 94.9,29.81 v1(95.25,29.46)
  BOTTOM w0.089: v1(77.83,77.52) 78.39,76.95 79.52,76.95 79.79,77.23 79.87,77.27 arc(79.94,77.31) 80.02,77.33 80.07,77.35 arc(80.1,77.36) 80.13,77.36 80.35,77.36 80.42,77.33 80.48,77.31 arc(80.5,77.3) 80.53,77.3 80.7,77.3 80.76,77.33 arc(80.77,77.33) 80.78,77.34 80.82,77.36 arc(80.85,77.37) 80.88,77.37 80.95,77.37 arc(80.97,77.37) 80.99,77.36 81.07,77.33 81.13,77.31 arc(81.15,77.3) 81.18,77.3 81.39,77.3 arc(81.46,77.28) 81.51,77.24 CPU1.AK61
  BOTTOM w0.14: DM1.143 v1(95.25,29.46)
M_A_DQ7: length 83.3
  TOP w0.14: v1(93.75,26.09) v2(93.75,26.69)
  L3 w0.127: v1(93.75,26.09) 93.67,26.17 93.67,26.91 93.54,27.03 93.29,27.03 93.16,26.91 93.16,26.29 93.03,26.17 92.78,26.17 92.65,26.29 92.65,27.19 93.67,28.21 93.67,33.77 68.6,58.84 68.6,65.14 69.08,65.62 69.08,69.81 67.58,71.31 67.58,74.03 68.88,75.32 73.34,75.32 75.44,77.42 v1(75.89,77.42)
  BOTTOM w0.089: CPU1.AK60 82.03,77.19 81.47,76.63 79.95,76.63 79.73,76.42 77.53,76.42 77.41,76.53 76.88,76.53 75.99,77.42 v1(75.89,77.42)
  BOTTOM w0.14: DM1.142 94.95,24.96 93.82,26.09 v1(93.75,26.09)
M_A_DQ8: length 73.2
  TOP w0.14: v2(77.42,74.49) 77.14,74.77 v1(77.14,75.04)
  L4 w0.127: v1(77.14,75.04) 76.7,74.6 74.98,74.6 73.4,73.02 73.4,71.96 69.41,67.97 69.41,67.14 52.91,50.63 52.91,50.46 53.09,50.28 53.27,50.28 56.13,53.14 56.31,53.14 56.49,52.96 56.49,52.78 52.55,48.84 52.55,29.99 52.21,29.64 52.21,29.27 v1(52.65,28.82)
  BOTTOM w0.089: v1(77.14,75.04) 77.57,75.47 77.72,75.47 78.11,75.86 79.93,75.86 79.96,75.88 79.96,75.88 80.08,76.01 CPU1.AM63
  BOTTOM w0.14: v1(52.65,28.82) 52.58,28.82 52.05,29.35 DM1.7
M_A_DQ9: length 74.4
  TOP w0.14: v1(76.94,75.73) 77.49,75.73 v2(77.54,75.79)
  L4 w0.127: v1(51.15,24.18) 50.68,24.65 50.68,30.36 51.37,31.05 51.37,50.87 66.6,66.09 66.6,73.35 66.6,73.35 66.6,74.01 66.6,74.01 66.6,74.06 68.74,76.2 76.49,76.2 76.94,75.75 v1(76.94,75.73)
  BOTTOM w0.089: CPU1.AM62 80.42,76.28 80.1,76.28 79.88,76.06 78.01,76.06 v1(76.94,75.73)
  BOTTOM w0.14: DM1.4 v1(51.15,24.18)
M_A_DQ10: length 72.3
  TOP w0.14: v1(54.45,28.19) 54.58,28.19 v2(54.94,27.83)
  L4 w0.127: v1(54.45,28.19) 54.6,28.34 54.6,28.35 54.89,28.64 54.89,29.75 54.23,30.41 54.23,48.14 68.28,62.19 68.28,62.37 68.1,62.55 67.92,62.55 64.94,59.57 64.76,59.57 64.58,59.75 64.58,59.93 71.09,66.44 71.09,67.28 75.08,71.27 75.08,72.31 75.64,72.88 76.61,72.88 77.05,73.32 v1(77.07,73.32)
  BOTTOM w0.089: CPU1.AP63 80.03,74.65 79.5,74.13 77.88,74.13 v1(77.07,73.32)
  BOTTOM w0.14: DM1.17 55.05,28.71 54.52,28.19 v1(54.45,28.19)
M_A_DQ11: length 73.5
  TOP w0.14: v2(55.93,24.63) 55.48,24.18 v1(55.35,24.18)
  L4 w0.127: v1(77.72,73.32) 77.7,73.32 76.86,72.48 75.93,72.48 75.47,72.02 75.47,71.11 71.48,67.12 71.48,66.28 68.36,63.16 68.36,62.98 68.54,62.8 68.72,62.8 71.08,65.15 71.26,65.15 71.44,64.97 71.44,64.8 54.62,47.98 54.62,30.57 55.29,29.91 55.29,26.68 54.81,26.2 54.81,24.72 v1(55.35,24.18)
  BOTTOM w0.089: v1(77.72,73.32) 77.72,73.54 78.11,73.93 79.55,73.93 79.57,73.95 79.99,74.37 80.49,74.37 80.78,74.65 CPU1.AP62
  BOTTOM w0.14: DM1.18 v1(55.35,24.18)
M_A_DQ12: length 74.7
  TOP w0.14: v1(76.29,75.73) v2(76.29,76.3)
  L4 w0.127: v1(76.29,75.73) 76.24,75.78 68.93,75.78 66.99,73.84 66.99,73.52 66.99,65.93 51.77,50.7 51.77,30.32 51.41,29.96 51.41,25.61 51.25,25.45 v1(51.15,25.45)
  BOTTOM w0.089: v1(76.29,75.73) 76.29,75.98 76.49,76.18 77.7,76.18 77.76,76.24 79.81,76.24 80.02,76.46 81.01,76.46 CPU1.AM61
  BOTTOM w0.14: DM1.6 51.75,24.93 51.22,25.45 v1(51.15,25.45)
M_A_DQ13: length 75.8
  TOP w0.14: v2(76.1,74.52) 75.75,74.86 v1(75.75,75.09)
  L4 w0.127: v1(52.65,27.55) 51.8,28.4 51.8,29.8 52.16,30.15 52.16,50.54 67.38,65.77 67.38,66.68 67.51,66.8 68.12,66.8 68.24,66.93 68.24,67.19 68.12,67.31 67.51,67.31 67.38,67.44 67.38,73.68 69.09,75.39 75.46,75.39 v1(75.75,75.09)
  BOTTOM w0.089: v1(75.75,75.09) 76.23,74.61 79.48,74.61 79.99,75.12 80.36,75.12 80.48,75.07 80.54,75.04 80.65,75.04 80.77,75.1 80.81,75.12 81.01,75.12 81.14,75.06 81.19,75.04 81.75,75.04 81.77,75.03 82.02,75.03 82.22,75.23 CPU1.AM60
  BOTTOM w0.14: v1(52.65,27.55) 52.47,27.74 52.46,27.74 51.45,28.75 DM1.5
M_A_DQ14: length 73.3
  TOP w0.14: v1(54.45,29.46) v2(54.45,30.09)
  L4 w0.127: v1(54.45,29.46) 54.45,29.63 53.84,30.25 53.84,48.31 64.53,59 64.53,59.18 64.35,59.36 64.17,59.36 60.49,55.68 60.31,55.68 60.13,55.86 60.13,56.04 70.7,66.61 70.7,67.44 74.69,71.43 74.69,72.49 75.51,73.32 v1(76.42,73.32)
  BOTTOM w0.089: CPU1.AP61 81.46,74.76 arc(81.34,74.84) 81.2,74.87 81.18,74.87 arc(81.15,74.87) 81.13,74.88 81.07,74.9 80.99,74.93 arc(80.97,74.94) 80.95,74.94 80.88,74.94 arc(80.85,74.94) 80.82,74.93 80.78,74.91 arc(80.77,74.9) 80.76,74.9 80.7,74.87 80.53,74.87 arc(80.5,74.87) 80.48,74.88 80.42,74.9 80.34,74.93 arc(80.32,74.94) 80.3,74.94 80.06,74.94 79.43,74.31 77.65,74.31 77.54,74.19 77.21,74.19 76.42,73.41 v1(76.42,73.32)
  BOTTOM w0.14: DM1.15 v1(54.45,29.46)
M_A_DQ15: length 74.5
  TOP w0.14: v2(55.93,25.9) 55.48,25.45 v1(55.35,25.45)
  L4 w0.127: v1(78.37,73.32) 77.89,72.84 77.78,72.84 77.03,72.09 76.3,72.09 75.96,71.75 75.96,70.97 71.88,66.89 71.88,64.68 55.11,47.9 55.11,47.73 55.28,47.55 55.46,47.55 57.87,49.95 58.05,49.95 58.23,49.77 58.23,49.59 55.02,46.38 55.02,30.74 55.72,30.03 55.72,26.34 55.79,26.27 55.79,25.9 55.72,25.83 55.72,25.82 v1(55.35,25.45)
  BOTTOM w0.089: CPU1.AP60 81.99,74.65 81.7,74.36 80.74,74.36 80.57,74.19 80.07,74.19 79.96,74.08 79.63,73.75 78.62,73.75 78.37,73.51 v1(78.37,73.32)
  BOTTOM w0.14: DM1.16 54.75,24.95 55.25,25.45 v1(55.35,25.45)
M_A_DQ16: length 74.1
  TOP w0.14: v2(98.37,27.88) 98.7,27.55 v1(98.85,27.55)
  L3 w0.127: v1(98.85,27.55) 99.29,28 99.29,29.96 99.17,30.09 98.94,30.09 98.81,30.21 98.81,30.47 98.94,30.59 99.17,30.59 99.29,30.72 99.29,30.98 99.17,31.1 98.94,31.1 98.81,31.23 98.81,31.48 98.94,31.61 99.17,31.61 99.29,31.74 99.29,31.99 99.17,32.12 98.94,32.12 98.81,32.25 98.81,32.5 98.94,32.63 99.17,32.63 99.29,32.75 99.29,33.01 99.17,33.14 98.94,33.14 98.81,33.26 98.81,35.5 96.79,37.52 96.79,37.7 96.97,37.87 97.15,37.87 98.55,36.48 98.73,36.48 98.91,36.66 98.91,36.84 75.24,60.51 75.24,67.59 78.75,71.11 79.83,71.11 81.39,72.67 82.55,72.67 83.49,73.6 83.49,74.09 83.06,74.52 v1(83,74.52)
  BOTTOM w0.14: v1(83,74.52) 83.04,74.52 83.36,74.85 CPU1.AP58 ; v1(98.85,27.55) 98.93,27.55 100.05,28.67 DM1.159
M_A_DQ17: length 73.2
  TOP w0.14: v2(98.37,29.15) 98.7,28.82 v1(98.85,28.82)
  L3 w0.127: v1(83.01,73.88) 82.19,73.06 81.23,73.06 79.67,71.5 78.58,71.5 73.95,66.87 73.95,61.23 96.76,38.43 96.76,38.25 96.58,38.07 96.4,38.07 93.41,41.06 93.23,41.06 93.05,40.88 93.05,40.7 98.41,35.34 98.41,29.27 v1(98.85,28.82)
  BOTTOM w0.14: v1(83.01,73.88) 83.01,73.89 83.31,74.2 CPU1.AR58 ; DM1.157 99.45,29.35 98.92,28.82 v1(98.85,28.82)
M_A_DQ18: length 76.2
  TOP w0.14: v1(96.15,24.18) v2(96.15,23.58)
  L3 w0.089: v1(83.92,75.83) 83.52,76.22 83.52,77.23 83.21,77.54 81.98,77.54
  L3 w0.127: 81.98,77.54 81.67,77.54 79.93,75.8 79.93,74.69 79.44,74.2 79.44,74.2 79.43,74.19 76.04,74.19 75.07,73.22 75.07,70.92 71.66,67.51 71.66,60.6 81.6,50.66 81.6,49.22 96.18,34.64 96.18,27.8 96.59,27.38 96.59,24.63 v1(96.15,24.18)
  BOTTOM w0.14: DM1.146 v1(96.15,24.18) ; CPU1.AM57 84.27,76.15 83.94,75.83 v1(83.92,75.83)
M_A_DQ19: length 77.8
  TOP w0.14: v1(96.15,25.45) v2(96.15,26.06)
  L3 w0.089: 81.92,77.96 82.24,77.96 82.37,77.83 83.5,77.83 83.97,77.36 v1(83.97,77.13)
  L3 w0.127: v1(96.15,25.45) 96.15,27.27 95.79,27.63 95.79,34.48 80.05,50.22 80.05,50.4 80.23,50.58 80.41,50.58 80.69,50.3 80.87,50.3 81.05,50.48 81.05,50.66 71.27,60.43 71.27,67.67 74.68,71.08 74.68,73.38 75.88,74.58 79.26,74.58 79.27,74.6 79.28,74.6 79.54,74.86 79.54,75.97 81.53,77.96 81.92,77.96
  BOTTOM w0.14: v1(96.15,25.45) 96.22,25.45 96.75,24.92 DM1.148 ; CPU1.AK57 84.26,77.45 83.97,77.15 v1(83.97,77.13)
M_A_DQ20: length 75.7
  TOP w0.14: v1(97.05,29.46) v2(97.05,30.02)
  L3 w0.127: v1(83.05,76.45) 81.7,76.45 80.72,75.46 80.72,74.37 79.23,72.88 76.51,72.88 75.88,72.25 75.88,70.62 72.51,67.24 72.51,60.86 88.4,44.98 88.4,44.8 88.22,44.62 88.04,44.62 85.08,47.57 84.9,47.57 84.72,47.39 84.72,47.21 97.05,34.89 v1(97.05,29.46)
  BOTTOM w0.14: DM1.149 v1(97.05,29.46) ; v1(83.05,76.45) 83.4,76.8 CPU1.AL58
M_A_DQ21: length 77.1
  TOP w0.14: v2(96.57,28.52) 96.9,28.19 v1(97.05,28.19)
  L3 w0.127: v1(97.05,28.19) 96.58,28.66 96.58,34.8 82,49.38 82,49.56 82.18,49.74 82.36,49.74 84.31,47.78 84.49,47.78 84.67,47.96 84.67,48.14 72.08,60.74 72.08,67.37 75.46,70.75 75.46,73.06 76.2,73.79 79.27,73.79 79.27,73.8 79.59,73.8 80.33,74.53 80.33,75.63 81.79,77.09 v1(83.03,77.09)
  BOTTOM w0.14: DM1.147 96.45,28.62 96.88,28.19 v1(97.05,28.19) ; v1(83.03,77.09) 83.38,77.45 CPU1.AK58
M_A_DQ22: length 74.3
  TOP w0.14: v2(99.87,25.78) 100.2,25.45 v1(100.35,25.45)
  L3 w0.127: v1(83.96,73.84) 83.96,73.37 82.16,71.57 80.85,71.57 79.99,70.71 78.91,70.71 75.63,67.43 75.63,60.67 99.69,36.61 99.69,36.36 99.56,36.23 99.33,36.23 99.21,36.1 99.21,35.85 99.33,35.72 99.56,35.72 99.69,35.6 99.69,35.34 99.56,35.21 99.33,35.21 99.21,35.09 99.21,34.83 99.33,34.71 99.56,34.71 99.69,34.58 99.69,34.33 99.56,34.2 99.33,34.2 99.21,34.07 99.21,33.82 99.33,33.69 99.56,33.69 99.69,33.56 99.69,25.65 99.56,25.52 99.31,25.52 99.18,25.65 99.18,26.28 99.05,26.41 98.8,26.41 98.67,26.28 98.67,25.06 98.9,24.83 99.73,24.83 v1(100.35,25.45)
  BOTTOM w0.14: DM1.158 99.75,24.93 100.28,25.45 v1(100.35,25.45) ; CPU1.AR57 84.32,74.2 83.97,73.84 v1(83.96,73.84)
M_A_DQ23: length 75.6
  TOP w0.14: v1(100.35,24.18) v2(100.35,23.58)
  L3 w0.127: v1(100.35,24.18) 100.79,24.63 100.79,26.27 100.1,26.97 100.1,36.76 77.04,59.82 77.04,62.67 76.91,62.8 76.66,62.8 76.53,62.67 76.53,60.84 76.4,60.72 76.15,60.72 76.02,60.84 76.02,67.27 79.07,70.32 80.16,70.32 80.95,71.11 82.36,71.11 82.77,71.52 82.95,71.52 83.21,71.26 83.39,71.26 83.57,71.44 83.57,71.62 83.31,71.88 83.31,72.06 83.49,72.24 83.67,72.24 83.93,71.98 84.11,71.98 84.29,72.16 84.29,72.34 84.03,72.6 84.03,72.78 84.41,73.16 84.41,74.71 83.96,75.16 v1(83.94,75.16)
  BOTTOM w0.14: CPU1.AN57 84.31,75.5 83.97,75.16 v1(83.94,75.16) ; DM1.160 v1(100.35,24.18)
M_A_DQ24: length 67.4
  TOP w0.14: v2(57.73,24.63) 57.28,24.18 v1(57.15,24.18)
  L4 w0.127: v1(57.15,24.18) 56.7,24.63 56.7,26.27 57.07,26.63 57.07,32.61 56.62,33.06 56.62,37.21 57.03,37.62 57.03,45.4 60.78,49.16 60.78,51.32 73.48,64.01 73.48,66.12 80.52,73.17 83.95,73.17 84.42,73.64 84.42,74.08 v1(84.86,74.53)
  BOTTOM w0.14: DM1.24 57.15,24.12 57.15,24.12 v1(57.15,24.18) ; CPU1.AP55 85.33,74.85 85.02,74.53 84.86,74.53 v1(84.86,74.53)
M_A_DQ25: length 66.8
  TOP w0.14: v1(57.15,25.45) 57.28,25.45 v2(57.73,25.9)
  L4 w0.127: v1(57.15,25.45) 57.59,25.9 57.59,26.54 57.46,26.68 57.46,32.83 57.01,33.28 57.01,37.04 57.42,37.46 57.42,45.24 61.18,48.99 61.18,51.15 73.87,63.85 73.87,65.96 80.73,72.82 84.13,72.82 84.69,73.38 84.69,73.72 84.86,73.89 v1(84.86,73.89)
  BOTTOM w0.14: v1(57.15,25.45) 57.03,25.45 56.55,24.97 DM1.22 ; CPU1.AR55 85.27,74.2 84.96,73.89 84.87,73.89 v1(84.86,73.89)
M_A_DQ26: length 69.8
  TOP w0.14: v1(60.15,25.45) 60.28,25.45 v2(60.73,25.9)
  L4 w0.089: 81.62,70.48 81.72,70.59
  L4 w0.091: 81.72,70.59 81.98,70.84 83.25,70.84 83.6,71.2 84.59,71.2 86.54,73.15 86.54,74.81 86.31,75.04 86.31,75.4 v1(85.89,75.82)
  L4 w0.127: 81.62,70.48 76.99,65.86 76.99,61.88 64.41,49.29 64.23,49.29 63.73,49.79 63.55,49.79 63.37,49.61 63.37,49.44 63.87,48.93 63.87,48.75 59.53,44.42 59.53,35.63 59.98,35.18 59.98,30.52 60.69,29.81 60.69,25.99 v1(60.15,25.45)
  BOTTOM w0.14: DM1.36 60.75,24.91 60.21,25.45 v1(60.15,25.45) ; v1(85.89,75.82) 86.22,76.15 CPU1.AM54
M_A_DQ27: length 70.8
  TOP w0.14: v2(60.73,24.63) 60.28,24.18 v1(60.15,24.18)
  L4 w0.127: v1(60.15,24.18) 61.08,25.11 61.08,29.97 60.37,30.68 60.37,35.34 59.92,35.79 59.92,44.24 77.38,61.7 77.38,64.93 79.7,67.25 80.32,67.25 83.94,70.87 84.7,70.87 86.91,73.08 86.91,74.8 87.21,75.1 87.21,77.46 86.96,77.7 86.42,77.7 v1(85.84,77.12)
  BOTTOM w0.14: v1(85.84,77.12) 85.96,77.12 CPU1.AK54 ; DM1.34 v1(60.15,24.18)
M_A_DQ28: length 69.7
  TOP w0.14: v2(56.72,27.83) 56.36,28.19 v1(56.23,28.19)
  L4 w0.089: 82.42,77.14 82.84,77.56 84.15,77.56 84.42,77.29 84.42,77 84.94,76.47 v1(84.94,76.47)
  L4 w0.127: 82.42,77.14 81.42,76.14 81.42,73.9 81.3,73.78 81.04,73.78 80.92,73.9 80.92,74.39 80.79,74.52 80.54,74.52 80.41,74.39 80.41,73.53 78.93,72.06 78.75,72.06 73.08,66.39 73.08,64.18 60.39,51.48 60.39,49.32 56.64,45.57 56.64,37.78 56.22,37.37 56.22,32.69 56.67,32.24 56.67,28.63 v1(56.23,28.19)
  BOTTOM w0.14: CPU1.AL55 85.27,76.8 v1(84.94,76.47) ; v1(56.23,28.19) 56.53,28.19 56.85,28.51 DM1.23
M_A_DQ29: length 69.9
  TOP w0.14: v1(56.23,29.46) v2(56.23,30.09)
  L4 w0.089: 81.74,77.66 81.91,77.84 84.28,77.84 84.89,77.23 v1(84.89,77.12)
  L4 w0.127: v1(56.23,29.46) 56.23,32.02 55.83,32.42 55.83,37.53 56.24,37.95 56.24,45.73 59.99,49.48 59.99,51.64 72.69,64.34 72.69,66.55 78.94,72.81 79.24,72.81 79.93,73.5 79.93,77.01 80.06,77.14 80.31,77.14 80.44,77.01 80.44,75.2 80.57,75.08 80.82,75.08 80.95,75.2 80.95,76.87 81.74,77.66
  BOTTOM w0.14: v1(84.89,77.12) 85.22,77.45 CPU1.AK55 ; DM1.21 56.25,29.48 v1(56.23,29.46)
M_A_DQ30: length 67.5
  TOP w0.14: v1(59.85,29.46) v2(59.85,30.09)
  L4 w0.091: 80.66,70.64 81.4,71.39 82.92,71.39 83.38,71.84 84.45,71.84 85.91,73.3 v1(85.91,73.82)
  L4 w0.127: v1(59.85,29.46) 59.19,30.12 59.19,34.85 58.74,35.3 58.74,44.74 62.46,48.46 62.46,50.08 64.02,51.65 64.2,51.65 67.84,55.29 68.02,55.29 68.2,55.11 68.2,54.93 66.26,52.99 66.26,52.81 66.44,52.63 66.62,52.63 76.2,62.21 76.2,66.18 80.66,70.64
  BOTTOM w0.14: v1(59.85,29.46) DM1.33 ; CPU1.AR54 86.28,74.2 v1(85.91,73.82)
M_A_DQ31: length 69.5
  TOP w0.14: v2(60.43,27.57) 60.43,27.74 59.98,28.19 v1(59.85,28.19)
  L4 w0.091: 80.9,70.32 81.71,71.13 83.08,71.13 83.5,71.55 84.56,71.55 86.33,73.31 86.33,74.7 85.89,75.13 v1(85.89,75.17)
  L4 w0.127: 80.9,70.32 76.59,66.02 76.59,62.04 65.48,50.92 65.3,50.92 65.12,51.1 65.12,51.28 66.05,52.22 66.05,52.4 65.87,52.58 65.69,52.58 64.28,51.16 64.13,51.16 62.85,49.88 62.85,48.3 59.14,44.58 59.14,35.47 59.59,35.02 59.59,30.35 60.29,29.64 60.29,28.64 60.07,28.41 60.07,28.41 v1(59.85,28.19)
  BOTTOM w0.14: DM1.35 60.45,28.71 59.92,28.19 v1(59.85,28.19) ; CPU1.AN54 86.31,75.48 86.31,75.27 86.21,75.17 v1(85.89,75.17)
M_A_DQ32: length 64.2
  TOP w0.14: v2(103.23,24.49) 102.9,24.82 v1(102.75,24.82)
  L3 w0.127: v1(102.75,24.82) 101.91,25.65 101.91,26.65 101.78,26.78 101.4,26.78 101.28,26.91 101.28,27.19 101.4,27.31 101.78,27.31 101.91,27.45 101.91,37.2 88.71,50.41 88.71,51.86 79.46,61.11 79.46,62.47 77.63,64.31 77.63,66.59 80.11,69.07 80.89,69.07 v1(81.07,69.26)
  BOTTOM w0.089: CPU1.AY58 83.31,70.94 83.31,70.84 83.22,70.76 83.22,70.21 82.48,69.47 81.89,69.47 81.68,69.26 v1(81.07,69.26)
  BOTTOM w0.14: DM1.166 102.15,24.22 102.56,24.63 102.57,24.63 v1(102.75,24.82)
M_A_DQ33: length 65.4
  TOP w0.14: v1(100.65,27.55) 100.8,27.55 v2(101.13,27.23)
  L3 w0.127: v1(100.65,27.55) 101.52,28.42 101.52,37.04 87.32,51.23 87.32,51.41 87.72,51.81 87.72,51.99 87.52,52.18 87.34,52.18 86.95,51.79 86.77,51.79 86.57,51.99 86.57,52.17 87.09,52.68 87.09,52.86 86.89,53.06 86.71,53.06 86.57,52.92 86.39,52.92 86.19,53.12 86.19,53.3 86.33,53.44 86.33,53.62 79.04,60.91 79.04,62.18 77.23,63.99 77.23,66.76 79.95,69.47 80.64,69.47 80.88,69.72 v1(81.51,69.72)
  BOTTOM w0.089: CPU1.AW58 83.13,71.41 83.13,70.91 83.04,70.82 83.04,70.28 82.48,69.72 v1(81.51,69.72)
  BOTTOM w0.14: v1(100.65,27.55) 100.83,27.74 100.84,27.74 101.85,28.75 DM1.165
M_A_DQ34: length 65
  TOP w0.14: v1(104.85,29.46) v2(104.85,30.02)
  L3 w0.127: v1(83.59,69.07) 83.59,67.79 82.13,66.34 82.13,62.15 104.24,40.04 104.24,39.86 104.05,39.66 103.87,39.66 100.46,43.07 100.28,43.07 100.08,42.87 100.08,42.69 104.43,38.34 104.43,30.57 104.85,30.15 v1(104.85,29.46)
  BOTTOM w0.089: CPU1.AY56 84.82,71.08 84.82,70.05 84.42,69.65 84.42,69.38 84.11,69.07 v1(83.59,69.07)
  BOTTOM w0.14: DM1.175 v1(104.85,29.46)
M_A_DQ35: length 65.9
  TOP w0.14: v1(104.55,24.18) v2(104.55,23.58)
  L3 w0.127: v1(82.65,68.21) 82.66,68.19 82.66,67.48 81.7,66.52 81.7,61.9 99.98,43.63 99.98,43.45 99.78,43.25 99.6,43.25 98.35,44.5 98.18,44.5 97.98,44.3 97.98,44.12 104.04,38.06 104.04,30.41 104.19,30.25 104.19,27.39 105.1,26.48 105.1,24.73 v1(104.55,24.18)
  BOTTOM w0.089: v1(82.65,68.21) 83.5,68.21 84.6,69.3 84.6,69.58 85,69.97 85,70.85 85.08,70.93 85.08,71.46 CPU1.AW56
  BOTTOM w0.14: v1(104.55,24.18) DM1.174
M_A_DQ36: length 65.7
  TOP w0.14: v1(100.65,28.82) 100.8,28.82 v2(101.13,29.15)
  L3 w0.127: v1(100.65,28.82) 101.12,29.3 101.12,36.88 85.86,52.14 85.86,52.32 86.05,52.5 86.05,52.68 85.86,52.88 85.68,52.88 85.49,52.69 85.31,52.69 85.11,52.89 85.11,53.07 85.61,53.57 85.61,53.75 85.41,53.95 85.23,53.95 84.73,53.45 84.55,53.45 84.36,53.64 84.36,53.82 84.85,54.32 84.85,54.5 84.65,54.7 84.47,54.7 83.98,54.2 83.8,54.2 83.6,54.4 83.6,54.58 84.04,55.02 84.04,55.24 83.77,55.51 83.59,55.51 83.47,55.38 83.29,55.38 83.09,55.58 83.09,55.76 83.22,55.89 83.22,56.07 78.23,61.05 78.23,62.34 76.82,63.75 76.82,67.02 79.66,69.87 80.47,69.87 80.8,70.19 v1(81.96,70.19)
  BOTTOM w0.089: v1(81.96,70.19) 81.96,70.37 82.48,70.89 82.48,71.24 82.8,71.57 82.84,71.57 83.46,72.18 CPU1.AV58
  BOTTOM w0.14: v1(100.65,28.82) 100.72,28.82 101.25,29.35 DM1.163
M_A_DQ37: length 66.9
  TOP w0.14: v1(102.75,26.09) 102.6,26.09 v2(102.27,26.41)
  L3 w0.127: v1(78.66,66.84) 78.66,66.84 78.02,66.2 78.02,64.52 79.88,62.66 79.88,61.27 89.59,51.56 89.59,50.08 102.31,37.37 102.31,26.22 102.44,26.09 v1(102.75,26.09)
  BOTTOM w0.089: v1(78.66,66.84) 80.39,66.84 82.29,68.74 82.54,68.74 83.79,69.99 84.22,69.99 84.46,70.23 84.46,70.74 84.36,70.84 84.36,71.21 84.4,71.3 84.42,71.36 84.42,71.47 84.34,71.63 84.34,71.83 84.4,71.96 84.42,72.01 84.42,72.12 84.42,72.13 84.42,72.61 84.43,72.63 84.43,72.84 84.23,73.04 CPU1.AU58
  BOTTOM w0.14: v1(102.75,26.09) 102.68,26.09 101.55,24.96 DM1.164
M_A_DQ38: length 66.4
  TOP w0.14: v1(104.85,28.19) 105,28.19 v2(105.33,28.52)
  L3 w0.127: v1(104.85,28.19) 105.36,28.7 105.36,30.2 104.82,30.74 104.82,40.05 87.61,57.26 87.61,58.77 85.41,60.97 85.23,60.97 85.03,60.77 85.03,60.59 87.05,58.57 87.05,58.39 86.85,58.19 86.68,58.19 82.56,62.31 82.56,66.18 84.58,68.19 84.58,69 84.08,69.51 84.05,69.51 v1(84,69.56)
  BOTTOM w0.089: CPU1.AV56 84.6,71.97 84.56,71.89 84.52,71.79 84.52,71.67 84.6,71.51 84.6,71.32 84.53,71.17 84.53,70.93 84.64,70.82 84.64,70.13 84.07,69.56 v1(84,69.56)
  BOTTOM w0.14: v1(104.85,28.19) 104.92,28.19 105.45,28.72 DM1.177
M_A_DQ39: length 67.5
  TOP w0.14: v2(105.03,25.78) 104.7,25.45 v1(104.55,25.45)
  L3 w0.127: v1(82.12,67.77) 81.49,67.77 81.22,67.5 79.36,65.64 79.36,65.21 81.23,63.33 81.23,61.77 97.86,45.15 97.86,44.97 97.66,44.77 97.48,44.77 97.09,45.16 96.91,45.16 96.71,44.96 96.71,44.78 103.59,37.9 103.59,30.22 103.8,30.01 103.8,25.89 104.24,25.45 v1(104.55,25.45)
  BOTTOM w0.089: v1(82.12,67.77) 83.32,67.77 84.78,69.23 84.78,69.5 85.17,69.9 85.17,70.78 85.26,70.86 85.26,71.78 84.99,72.05 84.99,72.75 CPU1.AU56
  BOTTOM w0.14: DM1.176 105.15,24.92 104.62,25.45 v1(104.55,25.45)
M_A_DQ40: length 62.1
  TOP w0.14: v1(62.55,24.18) 62.68,24.18 v2(63.13,24.63)
  L4 w0.127: v1(79.82,65.47) 79.62,65.47 78.98,64.84 78.98,60.89 68.8,50.71 68.8,50.53 68.98,50.35 69.16,50.35 69.31,50.5 69.49,50.5 69.67,50.32 69.67,50.14 62,42.47 62,31.81 62.49,31.32 62.49,26.91 62.04,26.46 62.04,24.69 v1(62.55,24.18)
  BOTTOM w0.089: CPU1.AY54 85.89,70.74 85.71,70.56 85.71,69.66 85.31,69.26 85.31,69.01 82.29,65.99
  BOTTOM w0.14: v1(79.82,65.47) 81.78,65.47 82.29,65.99 ; DM1.42 v1(62.55,24.18)
M_A_DQ41: length 62.9
  TOP w0.14: v2(61.12,28.58) 61.25,28.58 61.46,28.37 61.46,28.37 v1(61.65,28.19)
  L4 w0.127: v1(80.74,66.39) 79.98,66.39 78.59,65 78.59,61.05 67.35,49.81 67.35,49.63 67.53,49.45 67.71,49.45 68.41,50.16 68.59,50.16 68.77,49.98 68.77,49.8 65.31,46.34 63.73,46.34 61.61,44.21 61.61,31.64 62.09,31.16 62.09,28.63 v1(61.65,28.19)
  BOTTOM w0.089: 82.18,66.39 82.44,66.39 85.13,69.08 85.13,69.34 85.53,69.73 85.53,70.63 85.61,70.71 85.61,71.46 CPU1.AW54
  BOTTOM w0.14: 82.18,66.39 v1(80.74,66.39) ; v1(61.65,28.19) 61.78,28.32 61.86,28.32 62.25,28.72 DM1.41
M_A_DQ42: length 62.6
  TOP w0.14: v2(65.53,24.63) 65.08,24.18 v1(64.95,24.18)
  L4 w0.127: v1(64.95,24.18) 65.39,24.63 65.39,26.45 64.81,27.03 64.81,29.91 64.56,30.17 64.56,32.35 64.07,32.83 64.07,38.96 64.79,39.68 64.79,42.33 76.35,53.89 76.35,54.07 76.17,54.25 75.99,54.25 75.75,54.01 75.57,54.01 75.39,54.19 75.39,54.37 81.12,60.1 81.12,64.06 82.74,65.68 82.74,66 83.16,66.42 v1(83.61,66.42)
  BOTTOM w0.089: CPU1.AY52 87.33,71 87.33,69.85 87.63,69.55 87.63,69.31
  BOTTOM w0.14: DM1.50 v1(64.95,24.18) ; 87.63,69.31 87.63,68.7 85.35,66.42 v1(83.61,66.42)
M_A_DQ43: length 63.5
  TOP w0.14: v1(65.85,28.19) 66.29,28.19 v2(66.55,27.93)
  L4 w0.127: v1(83.18,65.26) 81.51,63.59 81.51,59.93 76.43,54.85 76.43,54.67 76.61,54.49 76.79,54.49 78.11,55.81 78.29,55.81 78.47,55.63 78.47,55.45 65.19,42.17 65.19,39.52 64.46,38.8 64.46,33 64.95,32.51 64.95,30.33 65.3,29.98 65.3,28.74 v1(65.85,28.19)
  BOTTOM w0.089: CPU1.AW52 87.4,71.46 87.48,71.26 87.51,71.19 87.54,71.13 87.54,69.89 88.07,69.36 88.07,69.24
  BOTTOM w0.14: v1(65.85,28.19) 65.78,28.19 65.25,28.71 DM1.51 ; v1(83.18,65.26) 83.58,65.26 84.3,65.98 85.55,65.98 88.07,68.5 88.07,69.24
M_A_DQ44: length 63.2
  TOP w0.14: v1(61.65,29.46) v2(61.65,30.09)
  L4 w0.127: v1(81.2,66.85) 79.85,66.85 78.19,65.19 78.19,61.22 64.99,48.01 64.99,47.84 65.17,47.66 65.35,47.66 66.9,49.2 67.08,49.2 67.26,49.02 67.26,48.84 65.15,46.73 63.56,46.73 61.21,44.38 61.21,31.48 61.65,31.04 v1(61.65,29.46)
  BOTTOM w0.089: 82.14,66.85 82.65,66.85 84.96,69.16 84.96,69.42 85.35,69.82 85.35,70.7 85.44,70.79 85.44,71.71 85.99,72.27 CPU1.AV54
  BOTTOM w0.14: DM1.39 61.65,29.46 v1(61.65,29.46) ; 82.14,66.85 v1(81.2,66.85)
M_A_DQ45: length 64.3
  TOP w0.14: v1(62.55,25.45) 62.68,25.45 v2(63.13,25.9)
  L4 w0.089: v1(86.51,69.34) 86.51,69.34 84.56,69.34 83.06,67.84 82.83,67.84 80.02,65.03 79.82,65.03
  L4 w0.127: v1(62.55,25.45) 62.99,25.9 62.99,26.29 62.88,26.4 62.88,31.48 62.39,31.97 62.39,42.3 70.15,50.06 70.15,51.5 79.38,60.73 79.38,64.59 79.82,65.03
  BOTTOM w0.089: CPU1.AU54 86.66,73.04 86.86,72.84 86.86,72.63 86.85,72.61 86.85,72.13 86.85,72.12 86.85,72.01 86.83,71.96 86.77,71.83 86.77,71.63 86.78,71.63 86.85,71.47 86.85,71.36 86.83,71.3 86.77,71.17 86.77,70.61 86.94,70.44 86.94,69.73 86.84,69.64
  BOTTOM w0.14: v1(86.51,69.34) 86.54,69.34 86.84,69.64 ; v1(62.55,25.45) 62.49,25.45 61.95,24.91 DM1.40
M_A_DQ46: length 63.9
  TOP w0.14: v2(65.53,25.9) 65.08,25.45 v1(64.95,25.45)
  L4 w0.127: v1(84.07,66.88) 83.19,66.88 80.73,64.42 80.73,60.26 74.99,54.53 74.99,53.09 63.68,41.77 63.68,41.02 63.8,40.89 64.25,40.89 64.38,40.76 64.38,40.51 64.25,40.38 63.8,40.38 63.68,40.25 63.68,32.67 64.16,32.18 64.16,30 64.42,29.74 64.42,25.63 64.6,25.45 v1(64.95,25.45)
  BOTTOM w0.089: CPU1.AV52 87.03,72.17 87.03,71.97 86.99,71.89 86.95,71.79 86.95,71.67 87.03,71.51 87.03,71.32 86.95,71.14 86.95,70.79 87.15,70.59 87.15,69.75 87.3,69.6 87.3,69.26
  BOTTOM w0.14: v1(84.07,66.88) 85.2,66.88 87.3,68.98 87.3,69.26 ; DM1.52 65.55,25.06 65.16,25.45 v1(64.95,25.45)
M_A_DQ47: length 64.6
  TOP w0.14: v2(66.42,29.47) 66.41,29.46 v1(65.85,29.46)
  L4 w0.127: v1(83.19,64.63) 81.91,63.34 81.91,59.77 78.57,56.43 78.57,56.25 78.75,56.07 78.93,56.07 81.25,58.4 81.43,58.4 81.61,58.22 81.61,58.04 65.58,42.01 65.58,39.36 64.88,38.66 64.88,33.14 65.34,32.67 65.34,30.49 65.85,29.99 v1(65.85,29.46)
  BOTTOM w0.089: CPU1.AU52 87.61,72.67 87.61,71.49 87.64,71.33 87.66,71.27 87.73,71.15 87.73,70.19 88.03,69.89
  BOTTOM w0.14: v1(83.19,64.63) 83.64,64.63 84.54,65.54 85.75,65.54 88.51,68.3 88.51,69.4 88.03,69.89 ; DM1.53 v1(65.85,29.46)
M_A_DQ48: length 72.9
  TOP w0.14: v2(70.54,27.83) 70.18,28.19 v1(70.05,28.19)
  L4 w0.089: 91.73,72.09 91.73,72.9 91.97,73.14 93.49,73.14 95.07,74.73 95.07,76.07 94.37,76.77 v1(94.37,77.13)
  L4 w0.127: 91.73,72.09 91.73,71.1 91.45,70.83 91.45,68.99 87.38,64.92 87.38,57.44 84.14,54.19 84.14,54.02 84.32,53.84 84.5,53.84 87,56.34 87.18,56.34 87.36,56.16 87.36,55.98 70.09,38.71 70.09,30.05 70.5,29.64 70.5,28.63 v1(70.05,28.19)
  BOTTOM w0.14: v1(94.37,77.13) 94.69,77.45 CPU1.AK40 ; DM1.69 70.65,28.71 70.13,28.19 v1(70.05,28.19)
M_A_DQ49: length 72.3
  TOP w0.14: v1(70.05,29.46) v2(70.05,30.09)
  L4 w0.089: 91.39,72.05 91.39,72.89 91.87,73.37 93.28,73.37 94.76,74.85 94.76,76 93.54,77.22 v1(93.47,77.22)
  L4 w0.127: 91.39,72.05 91.39,71.4 91.01,71.02 91.01,69.06 86.99,65.04 86.99,57.6 80.17,50.78 80.17,50.6 80.35,50.42 80.53,50.42 83.76,53.65 83.94,53.65 84.12,53.47 84.12,53.29 69.69,38.87 69.69,29.82 v1(70.05,29.46)
  BOTTOM w0.14: DM1.67 v1(70.05,29.46) ; v1(93.47,77.22) 93.69,77.45 CPU1.AK42
M_A_DQ50: length 69.9
  TOP w0.14: v2(68.38,29.5) 68.36,29.5 68.32,29.46 v1(67.65,29.46)
  L4 w0.089: v1(92.43,75.85) 92.16,75.85 91.3,74.99 90.35,74.99 90.1,74.73 90.1,73.76 88.59,72.26 88.59,71.98
  L4 w0.127: v1(67.65,29.46) 67.62,29.49 67.62,39.73 72.21,44.32 72.21,44.5 72.03,44.68 71.86,44.68 68.72,41.55 68.54,41.55 68.36,41.73 68.36,41.91 84.92,58.46 84.92,65.68 88.59,69.36 88.59,71.98
  BOTTOM w0.14: v1(92.43,75.85) 92.45,75.86 92.73,76.15 CPU1.AM43 ; v1(67.65,29.46) DM1.59
M_A_DQ51: length 69.8
  TOP w0.14: v1(67.65,28.19) 68.29,28.19 v2(68.35,28.14)
  L4 w0.089: v1(91.55,75.88) 90.89,75.21 89.62,75.21 89.41,75
  L4 w0.127: v1(67.65,28.19) 67.18,28.66 67.18,39.9 68.29,41.02 68.29,41.2 68.11,41.38 67.93,41.38 67.56,41.01 67.38,41.01 67.2,41.19 67.2,41.37 83.51,57.67 83.51,60.66 83.64,60.79 83.89,60.79 84.02,60.66 84.02,58.63 84.14,58.5 84.4,58.5 84.53,58.63 84.53,65.75 87.66,68.89 87.66,71.81 89.17,73.31 89.17,74.76 89.41,75
  BOTTOM w0.14: CPU1.AM45 91.82,76.15 v1(91.55,75.88) ; v1(67.65,28.19) 67.58,28.19 67.05,28.72 DM1.57
M_A_DQ52: length 69.9
  TOP w0.14: v1(91.57,77.18) 91.57,77.69 v2(91.64,77.77)
  L4 w0.091: 89,75.4 90.73,75.4 91.06,75.74 91.06,76.68 v1(91.57,77.18)
  L4 w0.127: v1(66.75,24.18) 67.21,24.64 67.21,26.56 66.79,26.98 66.79,41.51 83.11,57.83 83.11,61.99 83.24,62.11 83.5,62.11 83.62,61.99 83.62,61.32 83.75,61.19 84,61.19 84.13,61.32 84.13,65.8 87.33,69 87.33,72.16 88.44,73.27 88.44,74 88.09,74.36 88.09,74.83 88.66,75.4 89,75.4
  BOTTOM w0.14: CPU1.AK45 91.83,77.45 v1(91.57,77.18) ; DM1.56 v1(66.75,24.18)
M_A_DQ53: length 71.4
  TOP w0.14: v1(66.75,25.45) 66.88,25.45 v2(67.33,25.9)
  L4 w0.127: v1(66.75,25.45) 66.31,25.9 66.31,26.27 66.39,26.36 66.39,35.08 65.69,35.78 65.69,36.37 66.39,37.07 66.39,41.67 82.72,58 82.72,62.15 83.74,63.17 83.74,65.89 86.94,69.1 86.94,72.31 88.02,73.38 88.02,73.97 87.7,74.28 87.7,75 88.16,75.46 88.16,77.26 89.19,78.29 91.46,78.29 v1(92.51,77.25)
  BOTTOM w0.14: CPU1.AK43 92.7,77.45 v1(92.51,77.25) ; v1(66.75,25.45) 66.82,25.45 67.35,24.92 DM1.58
M_A_DQ54: length 71.7
  TOP w0.14: v1(70.95,25.45) v2(70.95,26.07)
  L4 w0.089: 91.03,72.06 91.03,72.86 91.77,73.61 93.2,73.61 93.95,74.37 93.95,75.43 v1(94.36,75.83)
  L4 w0.127: v1(70.95,25.45) 70.67,25.45 69.36,26.75 69.36,26.93 69.54,27.11 69.72,27.11 70.59,26.25 70.77,26.25 70.95,26.43 70.95,26.61 69.3,28.25 69.3,39.04 80.13,49.86 80.13,50.04 79.95,50.22 79.77,50.22 79.39,49.84 79.21,49.84 79.03,50.02 79.03,50.2 86.6,57.77 86.6,65.18 90.56,69.14 90.56,71.27 91.03,71.75 91.03,72.06
  BOTTOM w0.14: v1(94.36,75.83) 94.68,76.15 CPU1.AM40 ; DM1.68 70.35,24.85 70.76,25.27 70.77,25.27 v1(70.95,25.45)
M_A_DQ55: length 70.9
  TOP w0.14: v1(70.95,24.18) v2(70.95,23.56)
  L4 w0.089: 90.9,73.12 92.02,74.25 92.02,74.7 92.32,75 92.72,75 93.51,75.78 v1(93.51,75.89)
  L4 w0.127: v1(70.95,24.18) 70.4,24.73 70.4,25.16 70.25,25.31 70.07,25.31 69.95,25.19 69.77,25.19 69.59,25.37 69.59,25.55 69.71,25.67 69.71,25.85 68.91,26.65 68.91,39.2 79,49.29 79,49.47 78.82,49.65 78.64,49.65 77.25,48.26 77.07,48.26 76.89,48.44 76.89,48.62 86.2,57.93 86.2,65.34 90.15,69.29 90.15,72.37 90.9,73.12
  BOTTOM w0.14: DM1.70 v1(70.95,24.18) ; CPU1.AM42 93.77,76.15 v1(93.51,75.89)
M_A_DQ56: length 72.2
  TOP w0.14: v1(109.35,24.82) 109.49,24.82 v2(109.95,24.35)
  L3 w0.127: v1(109.35,24.82) 110.31,25.78 110.31,28.26 110.69,28.64 110.69,30.26 109.65,31.3 109.65,42.93 94,58.57 93.82,58.57 93.63,58.38 93.63,58.2 95.53,56.3 95.53,56.12 95.33,55.92 95.15,55.92 92,59.07 92,69.72 92.76,70.48 92.76,72.89 91.69,73.96 91.69,75.11 91.11,75.7 91.11,76.04 v1(90.6,76.55)
  BOTTOM w0.14: CPU1.AM46 91.09,76.21 90.75,76.55 v1(90.6,76.55) ; v1(109.35,24.82) 109.42,24.82 109.95,24.29 DM1.192
M_A_DQ57: length 71.8
  TOP w0.14: v2(110.59,25.39) 110.59,25.32 111.09,24.82 v1(111.15,24.82)
  L3 w0.127: v1(111.15,24.82) 110.71,25.26 110.71,26.53 110.83,26.66 111.16,26.66 111.29,26.79 111.29,27.04 111.16,27.17 110.83,27.17 110.71,27.3 110.71,28.09 111.15,28.54 111.15,30.36 110.05,31.46 110.05,43.09 93.36,59.78 93.18,59.78 92.98,59.58 92.98,59.4 93.44,58.94 93.44,58.76 93.24,58.56 93.06,58.56 92.4,59.23 92.4,69.56 93.16,70.32 93.16,74.06 93.01,74.21 93.01,77.46 92.54,77.93 91.34,77.93 v1(90.6,77.19)
  BOTTOM w0.14: v1(111.15,24.82) 111.08,24.82 110.55,24.29 DM1.194 ; v1(90.6,77.19) 90.86,77.45 CPU1.AK46
M_A_DQ58: length 69.4
  TOP w0.14: v1(107.25,29.46) v2(107.25,30.02)
  L3 w0.127: v1(88.58,75.85) 88.1,75.36 88.1,73.27 88.57,72.8 88.57,71.16 89.53,70.2 89.53,69.51 88.73,68.71 88.73,68.23 88.86,68.11 89.14,68.11 89.27,68.23 89.27,68.56 89.39,68.68 89.67,68.68 89.8,68.56 89.8,58.19 106.59,41.4 106.77,41.4 106.97,41.59 106.97,41.77 105.51,43.24 105.51,43.42 105.71,43.62 105.89,43.62 107.55,41.95 107.55,40.75 107.42,40.62 107.33,40.62 107.21,40.49 107.21,40.21 107.33,40.09 107.42,40.09 107.55,39.96 107.55,39.68 107.42,39.55 107.33,39.55 107.21,39.43 107.21,39.15 107.33,39.02 107.42,39.02 107.55,38.89 107.55,38.61 107.42,38.49 107.33,38.49 107.21,38.36 107.21,38.08 107.33,37.95 107.42,37.95 107.55,37.83 107.55,37.55 107.42,37.42 107.33,37.42 107.21,37.29 107.21,37.01 107.33,36.89 107.42,36.89 107.55,36.76 107.55,36.48 107.42,36.35 107.33,36.35 107.21,36.23 107.21,35.95 107.33,35.82 107.42,35.82 107.55,35.69 107.55,35.41 107.42,35.29 107.33,35.29 107.21,35.16 107.21,34.88 107.33,34.75 107.42,34.75 107.55,34.63 107.55,34.35 107.42,34.22 107.33,34.22 107.21,34.09 107.21,33.81 107.33,33.69 107.42,33.69 107.55,33.56 107.55,33.28 107.42,33.15 107.33,33.15 107.21,33.03 107.21,32.75 107.33,32.62 107.42,32.62 107.55,32.49 107.55,32.21 107.42,32.09 107.33,32.09 107.21,31.96 107.21,31.68 107.33,31.55 107.42,31.55 107.55,31.43 107.55,31.15 107.42,31.02 107.33,31.02 107.21,30.89 107.21,30.61 107.33,30.49 107.42,30.49 107.55,30.36 107.55,29.76 v1(107.25,29.46)
  BOTTOM w0.14: v1(88.58,75.85) 88.84,75.85 CPU1.AM49 ; DM1.183 v1(107.25,29.46)
M_A_DQ59: length 68.6
  TOP w0.14: v1(88.7,77.15) 88.7,77.61 v2(88.52,77.79)
  L3 w0.127: v1(88.7,77.15) 88.12,77.73 85.71,77.73 85.4,77.42 85.4,71.88 86.97,70.31 86.97,69.29 87.53,68.73 87.53,62.49 88.54,61.48 88.54,57.49 105.91,40.12 105.91,25.9 106.01,25.79 106.01,25.79 v1(106.35,25.45)
  BOTTOM w0.14: v1(88.7,77.15) 88.99,77.45 CPU1.AK49 ; DM1.182 106.95,24.93 106.42,25.45 v1(106.35,25.45)
M_A_DQ60: length 71
  TOP w0.14: v2(109.53,28.5) 109.2,28.82 v1(109.05,28.82)
  L3 w0.127: v1(109.05,28.82) 109.05,28.83 109.49,29.28 109.49,29.98 108.86,30.62 108.86,42.53 99.74,51.65 99.56,51.65 99.37,51.46 99.37,51.28 103.03,47.61 103.03,47.43 102.84,47.23 102.66,47.23 91.08,58.81 91.08,72.43 90.05,73.47 90.05,75.05 89.65,75.45 v1(89.65,75.82)
  BOTTOM w0.14: CPU1.AM48 89.97,76.15 v1(89.65,75.82) ; DM1.191 109.65,29.35 109.12,28.82 v1(109.05,28.82)
M_A_DQ61: length 70.3
  TOP w0.14: v1(110.25,29.46) v2(110.25,30.02)
  L3 w0.127: v1(110.25,29.46) 110.25,30.02 109.26,31.01 109.26,42.72 96.09,55.89 95.91,55.89 95.71,55.69 95.71,55.51 99.18,52.04 99.18,51.86 98.98,51.67 98.81,51.67 91.61,58.86 91.61,72.64 91.03,73.22 91.03,74.81 90.15,75.69 90.15,76.62 v1(89.65,77.12)
  BOTTOM w0.14: CPU1.AK48 89.97,77.45 v1(89.65,77.12) ; DM1.193 v1(110.25,29.46)
M_A_DQ62: length 68.2
  TOP w0.14: v1(107.25,28.19) 107.1,28.19 v2(106.77,27.86)
  L3 w0.127: v1(87.74,75.82) 87.69,75.77 87.69,74.99 87.07,74.36 87.07,72.97 88.08,71.96 88.08,71.08 88.63,70.53 88.63,69.22 88.34,68.93 88.34,64.22 88.47,64.09 88.74,64.09 88.87,64.22 88.87,67.49 89,67.61 89.28,67.61 89.4,67.49 89.4,57.78 106.8,40.39 106.8,28.42 107.03,28.19 v1(107.25,28.19)
  BOTTOM w0.14: CPU1.AM51 88.07,76.15 v1(87.74,75.82) ; v1(107.25,28.19) 107.18,28.19 106.65,28.71 DM1.181
M_A_DQ63: length 67.6
  TOP w0.14: v1(106.35,24.18) v2(106.35,23.58)
  L3 w0.127: v1(106.35,24.18) 106.51,24.18 106.97,24.64 106.97,26.93 106.3,27.61 106.3,40.28 89,57.58 89,63.51 88.87,63.63 88.59,63.63 88.47,63.51 88.47,62.66 88.34,62.53 88.06,62.53 87.93,62.66 87.93,69.06 87.36,69.63 87.36,70.95 86.37,71.95 86.37,74.22 87.3,75.15 87.3,76.66 87.74,77.1 v1(87.74,77.12)
  BOTTOM w0.14: DM1.180 v1(106.35,24.18) ; CPU1.AK51 88.07,77.45 v1(87.74,77.12)
M_A_DQS0: length 82.3
  TOP w0.127: v2(93.33,28.5) 93,28.82 v1(92.85,28.82)
  L3 w0.114: v1(92.85,28.82) 92.7,28.98 92.3,28.98 92.07,29.2 92.07,34.3 67.85,58.53 67.85,65.71 68.33,66.19 68.33,69.11 68.2,69.24 67.93,69.24 67.81,69.11 67.81,66.56 67.55,66.3 67.09,66.3 66.83,66.56 66.83,74.34 68.57,76.08 72.52,76.08 73.96,77.53 v1(74.87,77.53)
  BOTTOM w0.089: CPU1.AJ62 81.03,77.97 80.83,77.97 80.74,78.01 80.65,78.05 80.53,78.05 80.37,77.97 80.34,77.96 77.42,77.96 77.32,78.06 77.07,78.06 77.04,78.03 77.02,78.03
  BOTTOM w0.127: 77.02,78.03 75.38,78.03 v1(74.87,77.53) ; DM1.137 93.45,29.42 v1(92.85,28.82)
M_A_DQS1: length 73.4
  TOP w0.127: v2(53.97,23.77) 53.92,23.77 53.55,24.14 v1(53.55,24.18)
  L4 w0.114: v1(53.55,24.18) 53.41,24.32 52.88,24.32 52.62,24.59 52.62,26.65 53.27,27.3 53.27,29.75 53.08,29.93 53.08,48.62 57.31,52.85 57.31,53.01 56.85,53.48 56.85,53.83 57.19,54.17 57.54,54.17 58,53.7 58.16,53.7 58.37,53.91 58.37,54.07 57.91,54.54 57.91,54.89 58.25,55.23 58.6,55.23 59.06,54.77 59.22,54.77 59.38,54.92 59.38,56.36 69.94,66.92 69.94,67.76 73.93,71.75 73.93,72.81 75.2,74.08 77.43,74.08 77.79,74.44 v1(77.79,75.04)
  BOTTOM w0.089: CPU1.AN61 81.75,75.48 81.54,75.48 81.29,75.72 80.86,75.72 80.81,75.74 80.68,75.79 80.48,75.79 80.36,75.73 80.33,75.72 80.15,75.68 78.29,75.68 77.79,75.18 v1(77.79,75.04)
  BOTTOM w0.127: DM1.12 v1(53.55,24.18)
M_A_DQS2: length 74.9
  TOP w0.127: v1(97.95,24.82) 98.1,24.82 v2(98.43,25.14)
  L3 w0.114: v1(97.95,24.82) 97.78,24.82 97.47,25.12 97.47,26.67 97.85,27.05 97.85,35.15 92.26,40.74 92.26,40.9 92.72,41.36 92.72,41.72 92.38,42.06 92.03,42.06 91.57,41.6 91.41,41.6 91.2,41.8 91.2,41.96 91.66,42.43 91.66,42.78 91.32,43.12 90.97,43.12 90.51,42.66 90.35,42.66 90.14,42.86 90.14,43.02 90.6,43.49 90.6,43.84 90.26,44.18 89.91,44.18 89.45,43.72 89.29,43.72 89.15,43.85 89.15,45.29 73.32,61.12 73.32,66.98 78.36,72.03 79.45,72.03 81.53,74.11 81.53,74.96 81.92,75.35 82.83,75.35 v1(83.03,75.16)
  BOTTOM w0.127: CPU1.AN58 83.37,75.5 v1(83.03,75.16) ; DM1.154 98.55,23.8 98.41,23.94 98.41,24.35 v1(97.95,24.82)
M_A_DQS3: length 68.3
  TOP w0.127: v2(58.91,28.47) 58.55,28.82 v1(58.42,28.82)
  L4 w0.089: 81.12,71.83 81.14,71.83 81.16,71.81 82.51,71.81 83.1,72.39 84.2,72.39 85.28,73.47 85.28,74.84 v1(84.94,75.17)
  L4 w0.114: 81.12,71.83 80.78,71.83 75.39,66.44 75.39,62.51 71.2,58.31 71.04,58.31 70.68,58.68 70.31,58.68 69.99,58.35 69.99,57.98 70.35,57.62 70.35,57.46 70.14,57.25 69.98,57.25 69.34,57.9 68.97,57.9 68.64,57.57 68.64,57.2 69.29,56.56 69.29,56.4 68.94,56.06 66.82,56.06 61.7,50.94 61.7,48.77 57.99,45.06 57.99,34.99 58.44,34.54 58.44,32.57 57.99,32.12 57.99,29.26 v1(58.42,28.82)
  BOTTOM w0.127: v1(84.94,75.17) 85.01,75.17 CPU1.AN55 ; v1(58.42,28.82) 58.62,29.02 58.62,29.03 58.87,29.28 58.87,29.64 58.65,29.86 DM1.29
