# Allegro board Janus Intel MB_13302-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_VCC_IMON: length 3.9
  TOP w0.254: PU4601.3 119.4,119.83 119.61,119.62 119.82,119.62 v1(119.89,119.55)
  BOTTOM w0.254: PC4609.2 PR4610.2 119.82,119.62 v1(119.89,119.55) 119.95,119.62 120.11,119.62 v2(120.57,120.08)
PWR_VCC_ISUMN: length 3.4
  TOP w0.254: PR4706.2 PR4705.2 116.19,123.7 v2(116.5,123.4) 116.79,123.1 PU4601.9
PWR_VCC_ISUMP: length 23
  TOP w0.254: 108.96,125.07 97.95,125.07 v1(97.48,125.54) ; 108.96,125.07 v2(108.96,124.93) ; 108.96,125.07 112.6,125.07 113.27,124.41 PR4708.1 PC4707.1 PC4708.1 115.43,124.28 PR4707.1 115.43,123.52 116.29,122.66 PU4601.10
  BOTTOM w0.254: v1(97.48,125.54) 97.37,125.65 PR4703.1 96.66,124.78 PR4702.2
PWR_VCC_LG: length 15.8
  TOP w0.305: PU4601.16 115.49,118.52 115.22,118.25
  TOP w0.508: v3(113.93,117.46) 114.44,117.46 115.22,118.25
  L4 w1.016: v3(101.67,116.27) 101.8,116.15 112.62,116.15 v3(113.93,117.46)
  BOTTOM w0.711: v3(113.93,117.46) v2(114.59,117.46)
PWR_VCC_NTC: length 3
  TOP w0.254: PU4601.5 119.5,120.83 v2(120.19,121.52) 120.32,121.65 PR4615.2
PWR_VCC_NTC_R: length 26.9
  TOP w0.254: v1(120.06,122.92) 120.16,122.92 120.72,123.49 v2(121.18,123.49) 121.18,123.46 PR4617.1 PR4615.1
  BOTTOM w0.254: PR4622.1 112.13,113.1 113.86,114.83 114.8,114.83 117.81,117.84 120.02,117.84 121.4,119.22 121.4,122.33 120.81,122.92 v1(120.06,122.92)
PWR_VCC_PHASE: length 18.7
  TOP w0.305: v3(114.03,118.6) 114.26,118.6 114.92,119.26 114.95,119.26 115.01,119.33 PU4601.15
  TOP w0.762: v3(114.03,118.6) 113.3,118.6 PC4706.2
  L4 w1.016: v3(100.02,121.11) 104.04,121.11 105.82,119.32 112.76,119.32 113.48,118.6 v3(114.03,118.6)
  BOTTOM w0.711: v3(114.03,118.6) v2(113.37,118.6)
PWR_VCC_POK: length 2.6
  TOP w0.127: PR4628.1 120.7,118.73 v2(119.87,118.73) 119.27,119.33 PU4601.2
PWR_VCC_PRGM1: length 3.8
  TOP w0.254: PR4614.2 113.81,116.32 114.19,116.7 v2(114.41,116.7) 114.96,116.7 PU4601.17
PWR_VCC_PRGM2: length 4.9
  TOP w0.254: PU4601.11 115.11,121.33 114.29,122.16 114.29,122.68 113.58,123.39 113.07,123.39 v2(113.03,123.43) 112.97,123.38 112.55,123.38 112.32,123.15 PR4607.2
PWR_VCC_SCLK: length 3.7
  TOP w0.14: PU4601.20 117.79,117.62 v2(118.77,116.64) 118.77,116.6 119.14,116.23 PR4620.1 PR4616.1
PWR_VCC_SDA: length 3.8
  TOP w0.14: PR4619.1 PR4630.1 115.58,116.44 v2(115.83,116.69) 116.1,116.69 116.79,117.38 PU4601.18
PWR_VCC_UG: length 15.7
  TOP w0.305: PU4601.14 114.71,119.83 114.56,119.68 v3(114.43,119.68)
  L4 w1.016: v3(101.67,122.37) 101.79,122.25 104.51,122.25 106.3,120.46 113.64,120.46 v3(114.43,119.68)
  BOTTOM w0.711: v3(114.43,119.68) v2(114.43,120.34)
PWR_VCC_VRHOT#: length 2.5
  TOP w0.254: PR4624.1 120.44,119.78 119.88,120.34 119.78,120.34 v2(119.75,120.38) 119.71,120.33 PU4601.4
PWR_VGA_CORE_BOOT1: length 3.4
  BOTTOM w0.203: 154.61,77.67 154.29,77.98 PU8201.1
  BOTTOM w0.508: 154.61,77.67 PR8210.1 v2(154.61,75.25)
PWR_VGA_CORE_BOOT1_1: length 2.7
  BOTTOM w0.508: v2(158.32,77.25) 157.97,76.9 PC8211.1 156.44,76.9 PR8210.2
PWR_VGA_CORE_BOOT2: length 3
  BOTTOM w0.203: 154.75,82.57 154.6,82.42 154.6,82.21 154.29,81.9 PU8201.15
  BOTTOM w0.508: PR8211.1 154.47,83.98 155,83.45 v2(155,83) 155,82.82 154.75,82.57
PWR_VGA_CORE_BOOT2_1: length 2.8
  BOTTOM w0.508: PR8211.2 155.76,85.43 PC8216.1 155.76,86.26 v2(155.32,86.71)
PWR_VGA_CORE_EN: length 6.1
  BOTTOM w0.203: PU8201.3 153.49,77.86 153.29,77.65 153.29,76.4 v2(153.49,76.19)
  BOTTOM w0.254: PR8256.2 153.6,72.68 PR8260.2 PC8225.2 153.6,76.08 v2(153.49,76.19)
PWR_VGA_CORE_LGATE1: length 15.7
  TOP w0.508: v3(156.41,79.57) v2(157.5,79.57)
  L4 w1.016: v3(162.13,71.7) v3(162.13,77.28) 160.09,79.32 156.66,79.32 v3(156.41,79.57)
  BOTTOM w0.203: PU8201.19 156.3,79.68 v3(156.41,79.57)
  BOTTOM w0.508: v3(156.41,79.57) 156.79,79.19 PR8224.1
PWR_VGA_CORE_LGATE2: length 14.2
  TOP w0.508: v3(156.28,80.84) v2(157.2,80.84)
  L4 w1.016: v3(162.13,87.57) v3(162.13,81.98) 161.24,81.09 156.54,81.09 v3(156.28,80.84)
  BOTTOM w0.203: PU8201.17 155.92,80.48 v3(156.28,80.84)
PWR_VGA_CORE_PHASE1: length 22.8
  L4 w1.016: v3(155.27,78.55) 155.14,78.43 155.14,74.46 159.3,70.3 165.92,70.3 166.81,71.19 v3(168.86,71.19)
  BOTTOM w0.203: v3(155.27,78.55) 155.04,78.78 PU8201.20
  BOTTOM w0.508: v3(155.27,78.55) 155.6,78.22 PC8211.2
  vias: v2(171.02,72.43) v3(169.11,76.65) v3(169.11,75.51) v3(169.11,74.36) v3(169.11,73.22) v3(170.25,69.54) v3(170.25,68.39) v3(170.25,67.38) v3(170.38,76.27) v3(171.02,75.25) v3(171.65,76.27) v3(171.78,69.41) v3(171.78,68.14) v3(172.16,75.25)
PWR_VGA_CORE_PHASE2: length 23.1
  L4 w1.016: v3(155.14,81.73) 155.83,82.42 155.83,85.83 159.39,89.39 165.24,89.39 166.68,87.95 v3(168.98,87.95)
  BOTTOM w0.203: v3(155.14,81.73) 155.04,81.63 PU8201.16
  BOTTOM w0.508: PC8216.2 155.76,83.79 155.77,83.79 155.77,82.35 v3(155.14,81.73)
  vias: v2(171.46,88.35) v3(169.11,86.68) v3(169.11,85.29) v3(169.11,83.76) v3(169.11,82.49) v3(170,83.25) v3(170.13,84.4) v3(170.25,91.51) v3(170.25,90.11) v3(171.52,83.25) v3(171.65,84.4) v3(172.02,90.5)
PWR_VGA_CORE_PSI: length 5.4
  BOTTOM w0.203: 152.54,77.44 153.09,77.99 PU8201.4
  BOTTOM w0.254: PR8257.2 PR8258.2 PR8259.1 152.54,75.25 PC8226.2 v2(152.54,76.98) 152.54,77.44
PWR_VGA_CORE_REFADJ: length 3.7
  BOTTOM w0.203: PU8201.6 151.94,78.77
  BOTTOM w0.254: 151.94,78.77 150.55,77.39 v2(150.37,77.39) 149.69,77.39 PR8222.1
PWR_VGA_CORE_REFIN: length 4.9
  TOP w0.254: v2(150.85,78.22) 150.95,78.33 v1(150.95,78.81) 150.57,79.2 PR8209.1 PC8204.1
  BOTTOM w0.203: PU8201.7 151.24,79.68 150.95,79.39
  BOTTOM w0.254: PR8208.1 150.47,78.33 v1(150.95,78.81) 150.95,79.39
PWR_VGA_CORE_RGND: length 11.3
  TOP w0.14: v1(151.46,81.6) PC8201.1 PR8209.2 150.57,81.12 150.39,81.3 v2(150.26,81.3) 149.86,81.3 149.68,81.12 PC8204.2 PC8223.2
  BOTTOM w0.14: PU8201.10 151.69,80.88 151.46,81.11 v1(151.46,81.6) 151.55,81.7 151.55,83.48 PC8219.2 151.39,83.66 PC8217.1 PR8213.1 151.63,85.52 151.63,85.93 PR8220.1
PWR_VGA_CORE_SS: length 3.1
  TOP w0.254: v1(152.19,81.63) 152.16,81.66 152.16,81.89 151.86,82.19 v2(151.86,82.21) 151.85,82.21 151.58,82.48 v1(151.09,82.48)
  BOTTOM w0.203: PU8201.11 v1(152.19,81.63)
  BOTTOM w0.254: v1(151.09,82.48) 150.53,81.93 PC8205.1
PWR_VGA_CORE_TON: length 2.4
  BOTTOM w0.203: PU8201.9 151.07,80.48
  BOTTOM w0.254: PR8201.2 150.29,80.61 v2(150.68,80.61) 150.94,80.61 151.07,80.48
PWR_VGA_CORE_TON_1: length 4.3
  BOTTOM w0.254: PR8201.1 148.9,81.34 PC8202.2 149.23,82.2 148.95,82.2 v2(148.49,82.67) 148.49,83.3 149.01,83.82 PR8202.2
PWR_VGA_CORE_UGATE1: length 26.8
  TOP w0.508: v3(153.87,77.41) v2(154.76,77.41)
  L4 w1.016: v3(153.87,77.41) 153.87,73.93 158.77,69.03 166.44,69.03 167.33,69.92 v3(168.98,69.92) v3(168.98,66.11)
  BOTTOM w0.203: v3(153.87,77.41) 153.89,77.43 PU8201.2
PWR_VGA_CORE_UGATE2: length 26.3
  TOP w0.508: v2(154.15,83.84) v3(154.15,83.15)
  L4 w1.016: v3(168.98,93.03) v3(168.98,89.22) 167.21,89.22 165.77,90.66 158.86,90.66 154.56,86.35 154.56,83.56 154.15,83.15 v3(154.15,83.15)
  BOTTOM w0.203: v3(154.15,83.15) 154.15,82.85 154.14,82.84 154.14,82.37 153.89,82.12 PU8201.14
PWR_VGA_CORE_VID: length 5.6
  TOP w0.254: PC8203.2 152.66,78.24 v1(151.97,77.54)
  BOTTOM w0.203: v1(151.97,77.54) 152.69,78.26 PU8201.5
  BOTTOM w0.254: PR8207.2 150.08,75.48 v2(150.7,76.09) 151.06,76.46 151.06,76.9 151.52,77.35 151.78,77.35 v1(151.97,77.54)
PWR_VGA_CORE_VREF: length 13.2
  TOP w0.254: PC8201.2 151.46,79.03 151.46,79.02 151.46,77.98 150.38,76.9 v1(150.38,76.68)
  BOTTOM w0.203: PU8201.8 150.74,80.08
  BOTTOM w0.254: 150.74,80.08 150.69,80.04 149.89,80.04 149.64,80.28 PR8206.1 148.22,80.28 147.65,79.72 v2(147.65,78) 147.65,77.53 148.58,76.61 150.3,76.61 v1(150.38,76.68)
PWR_VGA_CORE_VSNS: length 5.8
  BOTTOM w0.14: PU8201.12 153.09,82.48 152.98,82.59 152.45,82.59 ; 152.45,82.59 152.11,82.59 151.95,82.75 151.95,83.32 PC8219.1 152.28,83.66 PC8222.1 PR8212.2 152.25,85.32 152.25,86.01 PR8221.1 ; 152.45,82.59 v2(152.45,82.72)
PWR_VGA_SNUB1:
  vias: v2(164.97,78.91)
PWR_VGA_SNUB2:
  vias: v2(164.95,80.13)
PWR_VRAM_PWR_EN: length 4.9
  BOTTOM w0.102: PU5102.1 160.71,61.03 160.78,61.1 160.78,61.46 160.6,61.64 PR5114.1 PR5104.1 162.1,62.23 162.91,63.04 v2(162.91,63.46)
PWR_VRAM_PWR_ILIM: length 2
  BOTTOM w0.254: PR5111.1 159.81,61.61 v2(159.81,61.48) PU5102.3
Q402_1: length 3.7
  TOP w0.102: RN3001.4 31.17,68.02 31.35,68.2 32.63,68.2 v2(32.85,67.98) 33.35,67.48 Q3003.B
Q6203_S: length 8
  BOTTOM w0.381: R6213.2 140.85,95.57 R6212.2 140.89,94.78 v2(140.89,93.51) Q6203.S 140.89,88.75 R6209.2 C6204.2
Q6204_G: length 29.4
  TOP w0.254: v1(136.28,100.99) 136.28,101.44 134.88,102.84 134.88,103.9 134.39,104.39 133.57,104.39 132.48,105.48 130.68,105.48 128.3,107.86 128.3,109.44 127.19,110.55 125.14,110.55 123.67,112.03 123.67,112.91 123.1,113.49 123.15,113.53 v1(123.19,113.53)
  BOTTOM w0.127: Q6204.5 Q6204.2 134.18,99.13 134.4,99.35 134.4,99.97 134.72,100.28 136.03,100.28 136.28,100.53 136.28,100.99 v1(136.28,100.99)
  BOTTOM w0.254: v1(123.19,113.53) 122.31,114.42 R6217.2 121.84,114.44 R6216.2
Q7601_G: length 11.8
  BOTTOM w0.102: Q7601.2 190.19,115.45 190.04,115.6 190.04,117.64 190.6,118.2 192.17,118.2 v2(192.43,117.95) 194.26,117.95 194.68,117.52 194.68,116.02 194.42,115.75 R7624.1 193.71,115.45 Q7601.5
REFIN_VREF: length 5.8
  TOP w0.254: PC8223.1 148.61,79.33 v1(148.61,78.26) 148.62,78.25 v2(149.32,78.25)
  BOTTOM w0.254: PR8208.2 149.83,79.66 149.17,79.66 148.91,79.39 PR8206.2 149.45,78.84 PR8222.2 148.87,78.52 v1(148.61,78.26)
REGOUT:
  vias: v2(49.45,64.36)
RING2: length 36.9
  TOP w0.203: HDA27.17 36.23,14.35 36.52,14.64 v3(36.52,14.88)
  TOP w0.305: RN2901.4 35.88,16.66 36.17,16.37 36.17,15.61 36.52,15.26 v3(36.52,14.88)
  TOP w0.508: v1(18.71,4.87) 18.53,5.05 EC2905.1 17.87,4.22 R2906.2
  L3 w1.016: v1(18.71,4.87) 20.31,3.27 25.77,3.27 26.41,3.92 26.41,7.26 25.86,7.81 25.86,10.73 26.78,11.65 28.34,11.65 29.61,10.38 31.41,10.38 32.51,11.47 32.51,13.09 33.31,13.89 35.53,13.89 v3(36.52,14.88)
  BOTTOM w0.508: v2(36.24,15.97) 36.52,15.69 v3(36.52,14.88)
RING2_R: length 12.2
  TOP w1.016: 15.34,2.25 14.68,1.59 5.81,1.59 HPMIC1.3
ROM_CS#: length 3.2
  TOP w0.127: R7626.1 174.94,111.93 175.33,112.31 175.33,112.62 175.59,112.89 176.08,112.89 v1(176.55,113.35)
  BOTTOM w0.102: v1(176.55,113.35) 176.16,113.75 GPU1.D12
ROM_SCLK: length 11.9
  BOTTOM w0.127: R7608.2 187.55,115.67 R7614.1 186.24,115.67 186.23,115.66 185.76,115.66 185.75,115.67 185.27,115.67 R7616.1 v2(184.27,115.66) 184.09,115.66 181.78,113.36 181.09,113.36 181.05,113.4 179.05,113.4 178.82,113.17 178.31,113.17 178.1,113.38 177.5,113.38 177.12,113.75 GPU1.C12
ROM_SI: length 14
  BOTTOM w0.127: R7638.2 188.12,117.43 R7639.2 187.3,117.43 R7619.2 187.3,117.43 R7618.1 185.63,117.43 R7640.1 184.8,117.43 R7642.1 R7641.1 183.86,117.43 183.62,117.18 183.62,116.91 183.01,116.3 v2(183.01,116.15) 183.01,114.95 181.68,113.61 181.29,113.61 181.27,113.64 178.97,113.64 178.96,113.63 178.72,113.39 178.4,113.39 178.19,113.6 178.16,113.6 178.15,113.62 177.88,113.62 GPU1.B12
ROM_SO: length 14.8
  BOTTOM w0.127: GPU1.A12 178.76,113.75 178.87,113.87 181.57,113.87 182.34,114.63 v2(182.34,114.93) 182.34,116.6 183.28,117.54 183.28,118.46 183.97,119.15 183.97,119.33 183.97,119.34 183.97,119.39 184.41,119.83 186.83,119.83 R7620.1 187.17,120.17 R7651.1 R7611.2
RRX: length 3.8
  TOP w0.102: U5502.28 20.22,79.7 v1(20.31,79.79)
  BOTTOM w0.102: v1(20.31,79.79) 20.22,79.7 19.1,79.7 v2(19,79.8) 19,80.36 19.09,80.45 R5505.1
RSET: length 4.7
  BOTTOM w0.203: LOM30.31 43.04,59.82 43.31,59.55
  BOTTOM w0.305: 43.31,59.55 43.31,58.97 v2(44.55,57.73) 45.42,56.86 R3032.2
RSMRST#_KBC: length 74.4
  TOP w0.127: KBC24.15 176.53,29.3 176.46,29.37 174.87,29.37 v1(174.47,29.77)
  L4 w0.127: v1(127.71,57.94) 131.14,57.94 132.34,56.74 132.34,55.75 133.22,54.88 133.22,54.42 134.05,53.59 134.05,50.61 134.33,50.33 135.18,50.33 140.33,45.17 141.74,45.17 144.43,42.49 144.92,42.49 146.95,40.45 147.67,40.45 148.27,39.86 148.98,39.86 149.83,39 153.46,39 154.23,38.24 156.92,38.24 158.89,36.27 158.89,34.03 v1(159.15,33.76)
  BOTTOM w0.127: v1(127.71,57.94) 127.38,57.94 127.12,57.68 127.12,57.68 126.5,57.05 124.38,57.05 124.09,57.34 124.09,59.47 R1702.2 ; v1(174.47,29.77) 172.47,29.77 171.71,30.53 166.73,30.53 165.92,29.72 164.56,29.72 v2(164.4,29.88) 163.78,30.5 163.78,32.52 162.8,33.5 159.68,33.5 159.67,33.51 159.4,33.51 v1(159.15,33.76)
RSVDA51: length 1.3
  TOP w0.102: TP606.1 v1(87.48,94.11)
  BOTTOM w0.102: CPU1.A51 87.87,93.71 v1(87.48,94.11)
RSVDAU63: length 5.7
  BOTTOM w0.102: TP602.1 76.2,70.63 76.83,71.26 78.19,71.26 79.97,73.04 CPU1.AU63
RSVDAV63: length 5.9
  BOTTOM w0.102: TP601.1 75.64,69.39 76.45,70.21 77.79,70.21 79.96,72.38 CPU1.AV63
RSVDB51: length 1.8
  TOP w0.102: v1(88.54,94.11) 88.54,93.57 TP607.1
  BOTTOM w0.102: v1(88.54,94.11) 88.54,93.6 CPU1.B51
RSVDC62: length 5.6
  TOP w0.102: v1(79.35,94.02) 80.37,93 TP604.1
  BOTTOM w0.102: v1(79.35,94.02) 79.08,93.75 79.08,92.58 79.32,92.34 79.76,92.34 80.03,92.07 80.53,92.07 80.79,92.33 CPU1.C62
RSVDC63: length 1.7
  TOP w0.102: TP603.1 79.93,92.3 v1(79.49,92.75)
  BOTTOM w0.102: v1(79.49,92.75) 79.58,92.66 79.75,92.66 79.93,92.48 79.94,92.48 80.02,92.4 CPU1.C63
RSVDL60: length 2.6
  TOP w0.102: v1(81.9,87.66) 81.46,88.1 80.95,88.1 80.46,87.62 TP608.1
  BOTTOM w0.102: CPU1.L60 82.22,87.35 v1(81.9,87.66)
RSVDN59: length 1.2
  TOP w0.102: v1(83.3,86.85) 83.34,86.85 83.43,86.94 TP704.1
  BOTTOM w0.102: v1(83.3,86.85) 83.02,86.57 CPU1.N59
RSVDN61: length 1.2
  TOP w0.102: v1(81.91,86.15) 81.91,86.01 TP705.1
  BOTTOM w0.102: CPU1.N61 81.57,86.5 v1(81.91,86.15)
RSVDP60: length 2.9
  TOP w0.102: TP702.1 84.02,85.03 v1(84.06,84.99)
  BOTTOM w0.102: CPU1.P60 82.44,85.75 82.8,85.38 83.61,85.38 84,84.99 v1(84.06,84.99)
RSVDP61: length 2.3
  TOP w0.102: TP703.1 82.61,84.7 v1(82.57,84.66)
  BOTTOM w0.102: CPU1.P61 81.9,85.41 82.35,85.41 82.53,85.23 82.53,84.7 v1(82.57,84.66)
RT8812_PVCC: length 5.2
  BOTTOM w0.127: PU8201.18 156.15,80.08 156.18,80.12 156.91,80.12 PC8207.1 PR8223.2 157.27,82.26 v2(156.57,82.96)
RTC_AUX_S5: length 217.5
  TOP w0.305: 113.29,77.44 113.38,77.53 113.38,78.43 113.25,78.55 v1(112.84,78.55)
  TOP w0.508: 113.29,77.44 112.93,77.08 112.93,74.68 112.53,74.28 112.53,73.27 113.02,72.78 113.02,72.32 113.63,71.71 113.63,70.97 ; v1(62.56,19.49) 62.66,19.39 62.66,18.53 54.35,10.23 v1(54.35,10.12)
  L3 w0.508: v1(112.96,48.63) 112.85,48.52 112.85,37.33 114.02,36.15 114.02,28.81 113.62,28.4 113.62,19.98 109.75,16.11 109.75,13.16 108.34,11.74 102.34,11.74 101.94,11.34 101.94,11.34 99.38,8.78 88.36,8.78 83.9,13.24 79.06,13.24 74,18.3 69.74,18.3 68.86,17.42 63.93,17.42 62.56,18.79 v1(62.56,19.49)
  L4 w0.508: v1(121.4,54.41) 121.41,54.4 121.41,53.37 118.79,50.75 115.07,50.75 v1(112.96,48.63)
  BOTTOM w0.254: CPU1.AG10 112.87,78.55 v1(112.84,78.55)
  BOTTOM w0.508: C2503.1 54.71,5.63 54.36,5.98 D2501.3 54.36,9.61 54.38,9.62 54.38,10.09 v1(54.35,10.12) ; R1903.1 117.88,60.87 119.64,59.11 119.64,57.75 120.75,56.64 120.75,55.06 v1(121.4,54.41) 121.4,51.7 117.99,48.28 117.99,46.62 118.36,46.25 121.18,46.25 122.59,47.65 141.76,47.65 141.76,47.66 142.26,47.66 144.27,45.64 144.27,41.55 146.03,39.79 146.03,35.31 147.11,34.23 147.11,32.6 151.66,28.05 153.12,28.05 154.19,26.97 156.56,26.97 159.77,23.77 160.68,23.77 161.68,24.76 164.88,24.76 165.13,25.01 166.13,25.01 166.61,24.53 167.58,24.53 167.88,24.83 R2428.2 ; v1(123.71,60.89) 123.71,61.06 123.09,61.68 R1720.2
  vias: v2(113.79,69.6)
RTC_DET#: length 204.4
  TOP w0.102: v1(127.99,76.65) 126.72,76.65 v2(125.6,77.77) 125.32,78.05 124.52,78.05 123.52,79.05 122.32,79.05 122.29,79.02 122.28,79.02 122.17,78.92 121.07,78.92 119.8,80.19 119.8,81.13 119.52,81.41 118.98,81.41 118.86,81.3 116.55,81.3 v1(116.44,81.19)
  L3 w0.102: v1(131.49,72.43) 131.89,72.03 131.89,69.36 134.22,67.03 134.22,66.91 135.7,65.43 135.7,60.23 135.7,60.23 135.7,59.53 135.33,59.15 135.33,59.04 132.7,56.41 132.7,51.05 136.32,47.43 136.32,43 136.75,42.57 138.84,42.57 141.85,39.57 141.85,38.21 144.55,35.5 144.55,33.22 145.32,32.46 145.32,29.45 145.32,23.4 148.1,20.62 148.1,7.98 145.04,4.92 v1(145.04,4.13)
  L4 w0.102: v1(52.77,10.66) 52.86,10.75 55,10.75 55.32,10.43 70.86,10.43 77.65,3.64 105.84,3.64 106.2,4.01 109.53,4.01 110.65,2.88 128.98,2.88 129.8,3.7 129.9,3.7 129.93,3.74 132,3.74 132.82,2.92 143.84,2.92 v1(145.04,4.13) ; v1(127.99,76.65) 128.52,76.65 129.25,75.92 131.47,75.92 131.95,75.44 131.95,72.89 v1(131.49,72.43)
  BOTTOM w0.102: Q2505.D 50.64,8.53 v1(52.77,10.66) ; CPU1.AD5 116.26,81.01 v1(116.44,81.19) ; RN2012.6 132.01,71.54 131.93,71.62 131.93,71.62 131.74,71.8 131.74,72.18 v1(131.49,72.43)
RTC_PWR: length 6.3
  BOTTOM w0.508: D2501.2 51.65,6.74 Q2505.G 51.13,6.23 51.13,5.18 R2504.1 51.01,4.24 50.77,4.01 v2(50.44,4.01) 50.14,4.31 R2502.1
RTC_RST#: length 16.6
  TOP w0.127: Q1901.D 120.8,61.02 120.6,61.22 G1901.2 120,63.34 RN1901.3 119.4,64.79 C1901.1 120,65.39 120,65.47 120,65.48 120,67.49 119.14,68.35 119.14,69.33 118.09,70.38 v2(118.09,70.41) 115.78,72.72 v1(115.14,72.72)
  BOTTOM w0.089: v1(115.14,72.72) 115.13,72.72 115.05,72.72 CPU1.AU7
RTC_X1: length 11.3
  BOTTOM w0.089: 117.19,70.38 116.64,70.93 116.64,71.37 CPU1.AW5
  BOTTOM w0.14: 117.19,70.38 117.52,70.04 118.72,70.04 119.31,69.45 119.31,69.4 120.44,68.26 v2(120.44,67.43) 120.44,66.41 120.69,66.16 R1915.1 C1903.2 122.29,66.16 122.97,65.48 X1901.1
RTC_X2: length 11.4
  BOTTOM w0.14: X1901.4 123,64.62 122.28,65.35 C1904.2 121.69,65.35 121.61,65.27 R1915.2 120.4,65.27 v2(120.13,65.54) 119.75,65.92 119.75,68.17 118.24,69.68 117.49,69.68 116.34,70.84 116.34,71.06 CPU1.AY5
RTCRST_ON: length 82.9
  TOP w0.127: v1(122.04,56.86) 121.94,56.96 R1902.1 121.4,57.59 121.21,57.78 121.21,58.09 120.88,58.41 120.4,58.41 120.33,58.35 Q1901.G ; v1(172.64,24.17) 172.78,24.17 172.96,23.99 172.96,23.28 172.89,23.2 KBC24.120
  L4 w0.127: v1(122.04,56.86) 122.28,56.62 126.8,56.62 128.52,54.91 128.98,54.91 129.66,54.23 129.66,53.97 131.26,52.36 131.26,51.89 131.51,51.65 131.51,47.34 133.72,45.13 133.72,43.81 134.91,42.62 139.75,42.62 139.99,42.37 140.44,41.93 141.71,41.93 144.08,39.57 144.57,39.57 145.99,38.14 146.71,38.14 147.31,37.55 148.01,37.55 149.27,36.29 149.27,33.83 151.35,31.75 151.56,31.75 154.68,31.75 155.03,32.1 155.03,34.23 155.54,34.74 157,34.74 157.54,34.19 157.54,32.44 158.44,31.54 158.44,27 v1(159.79,25.66)
  BOTTOM w0.127: v1(159.79,25.66) 160.03,25.42 v2(161.18,25.42) 162.1,25.42 162.31,25.21 164.7,25.21 164.95,25.46 166.32,25.46 166.8,24.98 167.39,24.98 167.72,25.3 171.51,25.3 v1(172.64,24.17)
S5_ENABLE: length 35.8
  TOP w0.127: v1(173.99,29.23) 174.1,29.12 176.24,29.12 176.46,28.9 KBC24.14 ; R3603.2 151.21,27.09 150.29,28.01 v2(150.29,28.8) 150.29,29.71 v1(150.59,30.01) 151.52,30.94 Q2403.D
  BOTTOM w0.127: v1(173.99,29.23) 172.65,29.23 171.61,30.27 168.96,30.27 R2436.2 166.85,28.73 166.11,29.46 164.29,29.46 163.71,30.05 160.71,30.05 160.5,30.26 160.49,30.26 160.41,30.34 157.9,30.34 157.76,30.2 151.52,30.2 151.38,30.07 150.64,30.07 v1(150.59,30.01)
SA0_DIMA: length 5.5
  TOP w0.102: v1(113.28,33.85) 113.28,34.26 113.15,34.38 v2(112.93,34.38) 112.45,34.38 R1201.1
  BOTTOM w0.102: v1(113.28,33.85) 111.45,32.02 DM1.197
SA1_DIMA: length 3.6
  TOP w0.102: v1(113.26,32.38) 113.26,32.02 v2(112.9,31.67) 112.6,31.67 R1202.1
  BOTTOM w0.102: DM1.201 112.65,31.77 v1(113.26,32.38)
SATA3_PRX_HDDTX_N0: length 156
  L4 w0.114: v1(115.81,88.78) 116.07,89.04 116.43,89.04 117.2,89.81 117.51,89.81 118.93,91.23 118.93,92.32 120.19,93.59 120.19,94.13 120.51,94.45 124.31,94.45 126.6,96.75 128.34,96.75 129.19,97.6 131.09,97.6 131.98,98.49 136.47,98.49 137.7,97.27 137.7,92.88 138.26,92.32 138.26,91.15 138.8,90.61 138.8,88.13 137.7,87.03 137.7,75.2 138.56,74.33 138.56,57.57 140.51,55.62 140.51,53.19 148.36,45.34 161.78,45.34 163.37,43.75 179.53,43.75 182.34,40.93 183.78,40.93 186.52,38.19 186.52,34.09 185.9,33.47 185.9,17.34 185.14,16.59 185.14,14.87 v1(184.79,14.52)
  BOTTOM w0.127: CPU1.J5 116.1,88.49 v1(115.81,88.78) ; 185.87,12.08 186.91,11.03 187.25,11.03 C5616.1 ; 185.87,12.08 v2(185.78,11.99) ; 185.87,12.08 185.15,12.8 185.15,14.16 v1(184.79,14.52)
SATA3_PRX_HDDTX_P0: length 156
  L4 w0.114: v1(115.82,89.46) 116.01,89.27 116.34,89.27 117.11,90.04 117.42,90.04 118.7,91.32 118.7,92.42 119.96,93.68 119.96,94.23 120.42,94.68 124.21,94.68 126.51,96.98 128.24,96.98 129.09,97.83 131,97.83 131.89,98.72 136.57,98.72 137.93,97.36 137.93,92.98 138.49,92.42 138.49,91.24 139.03,90.7 139.03,88.04 137.92,86.93 137.92,75.29 138.79,74.43 138.79,57.66 140.74,55.71 140.74,53.29 148.46,45.57 161.87,45.57 163.47,43.97 179.62,43.97 182.44,41.16 183.88,41.16 186.75,38.29 186.75,33.99 186.13,33.38 186.13,17.25 185.37,16.49 185.37,14.95 v1(185.78,14.54)
  BOTTOM w0.127: v2(185.51,13.43) 185.39,13.43 ; 185.39,13.43 185.39,14.15 v1(185.78,14.54) ; 185.39,13.43 185.39,12.9 187.01,11.28 187.25,11.28 C5615.1 ; CPU1.H5 116.14,89.14 v1(115.82,89.46)
SATA3_PTX_HDDRX_N0: length 168.9
  TOP w0.127: v1(110.87,95.21) v2(111.43,95.21)
  L4 w0.114: v1(186.89,9.85) 187.24,9.5 187.38,9.5 187.69,9.81 187.69,10.78 190.27,17.51 190.27,36.52 189.07,41.75 184.12,46.7 164.55,46.7 163.5,47.75 149.2,47.75 142.9,54.06 142.9,56.41 142.09,57.22 141.65,57.65 141.65,59.79 141.05,60.4 141.05,92.79 140.38,93.46 140.38,97.69 140.1,97.97 140.1,98.81 137.25,101.66 134.64,101.66 134.48,101.82 129.34,101.82 126.57,99.05 124.48,99.05 124.03,99.5 123.28,99.5 122.12,98.35 122.12,98.12 121.19,97.18 117.99,97.18 115.96,95.96 113.27,95.96 111.64,95.43 111.09,95.43 v1(110.87,95.21)
  BOTTOM w0.127: CPU1.B15 109.78,93.07 110.27,93.56 110.27,95.32 110.42,95.47 110.6,95.47 v1(110.87,95.21) ; C5603.2 v1(186.89,9.85)
SATA3_PTX_HDDRX_P0: length 169.2
  TOP w0.127: v1(110.9,95.84) 110.9,95.94 v2(111.4,96.44)
  L4 w0.114: v1(110.9,95.84) 111.08,95.66 111.6,95.66 113.23,96.19 115.9,96.19 117.93,97.41 121.09,97.41 121.89,98.21 121.89,98.44 123.18,99.73 124.12,99.73 124.57,99.28 126.47,99.28 129.24,102.05 134.57,102.05 134.73,101.89 137.34,101.89 140.33,98.91 140.33,98.06 140.61,97.78 140.61,93.56 141.28,92.89 141.28,60.49 141.88,59.89 141.88,57.75 142.31,57.32 142.31,57.32 143.12,56.51 143.12,54.15 149.29,47.98 163.6,47.98 164.64,46.93 184.21,46.93 189.28,41.86 190.5,36.54 190.5,17.47 187.91,10.74 187.91,9.71 187.47,9.27 187.2,9.27 v1(186.89,8.96)
  BOTTOM w0.127: CPU1.A15 110.03,93.79 110.03,95.42 110.32,95.71 110.77,95.71 v1(110.9,95.84) ; C5602.2 v1(186.89,8.96)
SATA_IREF: length 4.2
  BOTTOM w0.305: CPU1.A12 112.13,94.07 112.13,95.3 112.55,95.72 112.87,95.72 v2(113.18,96.02) 113.66,96.5 R1904.1
SATA_LED#: length 19.5
  TOP w0.102: v1(121.19,84.2) 121.49,84.5 121.49,86.3 121.94,86.76 121.94,87.22 123.06,88.33 123.06,88.51 124.57,90.02 124.57,91.26 124.99,91.67 124.99,91.72 124.99,91.72 124.99,92.35 125.4,92.76 v2(125.4,94.66) 125.47,94.73 125.47,95.78 125.09,96.16 R1905.2
  BOTTOM w0.089: v1(121.19,84.2) 120.98,84.4 120.07,84.4 120.06,84.4 119.54,84.4 119.1,83.96 117.84,83.96 CPU1.U3
SATA_ODD_DA#: length 104.8
  TOP w0.127: RN2002.7 122.39,93.29 121.53,92.43 121.53,90.04 121.66,89.91 121.66,89.24 121.51,89.09 121.51,88.67 v2(121.18,88.33) 121.01,88.16 121.01,87.16 120.32,86.47 120.32,86.28 120.02,85.99 119.52,85.99 118.19,84.66 117.93,84.66 v1(117.89,84.62)
  L3 w0.127: v1(132.84,93.26) 133.26,92.84 133.69,92.84 135.23,94.38 136.8,94.38 137.29,94.87 143.3,94.87 143.9,95.48 149.42,95.48 149.42,95.48 149.67,95.48 150.65,96.46 v1(151.46,96.46)
  L4 w0.127: v1(117.89,84.62) 118.35,84.62 119.62,85.89 120.47,85.89 122.45,87.87 122.71,87.87 124.99,90.16 125.39,90.16 128.24,93.01 128.24,93.41 128.62,93.79 129.11,93.79 129.54,94.23 131.88,94.23 v1(132.84,93.26)
  BOTTOM w0.127: R5602.2 193.56,86.49 194.52,87.45 194.52,90.98 189.88,95.63 185.84,95.63 185.01,96.47 175.13,96.47 174.73,96.87 174.35,96.87 173.68,97.54 155.22,97.54 154.64,98.11 153.26,98.11 151.61,96.46 v1(151.46,96.46) ; v1(117.89,84.62) 117.59,84.92 CPU1.T3
SATA_ODD_DA#_C: length 6.8
  BOTTOM w0.127: ODD1.4 199.56,85.54 v2(196.06,85.54) R5602.1
SATA_ODD_PRSNT#: length 119.1
  TOP w0.127: v1(120.78,85.45) 120.91,85.58 120.91,86.38 121.49,86.96 121.49,87.43 122.46,88.4 122.46,89.25 122.29,89.43 RN1902.1 ; v1(192.29,79.58) v2(194.76,79.58) 195.72,79.58 v1(195.84,79.69)
  L3 w0.127: v1(153.36,97.22) 153.1,97.48 150.7,97.48 149.39,96.17 143.62,96.17 143.01,95.56 136.37,95.56 135.68,94.86 134.76,94.86 133.9,94 131.77,94 v1(131.42,93.64)
  L4 w0.127: v1(131.42,93.64) 130.35,93.64 129.15,92.44 128.02,92.44 123.41,87.83 123.14,87.83 121.99,86.68 121.74,86.68 121.49,86.43 121.49,86.15 v1(120.78,85.45)
  BOTTOM w0.102: 202.25,78.29 ODD1.1
  BOTTOM w0.127: v1(120.78,85.45) 120.78,85.12 120.47,84.8 120.19,84.8 119.98,84.6 119.25,84.6 CPU1.U1 ; 202.25,78.29 200.02,76.06 R5604.1 196.85,78.68 v1(195.84,79.69) ; v1(153.36,97.22) 154.81,97.22 155,97.03 173.47,97.03 174.14,96.37 174.51,96.37 174.92,95.96 184.8,95.96 185.63,95.13 189.66,95.13 193.83,90.96 193.83,89.93 193.11,89.21 193.11,87.27 191.5,85.66 191.5,80.37 v1(192.29,79.58)
SATA_ODD_PWRGT: length 115.8
  L3 w0.127: v1(135.33,90.75) 135.39,90.81 137.91,90.81 138.16,90.56 145.02,90.56 146.98,92.52 149.88,92.52 150.7,93.34 150.7,95.45 151.2,95.95 v1(153.36,95.95)
  L4 w0.127: v1(135.33,90.75) 135.33,91.19 134.69,91.83 134.69,93.16 132.71,95.14 132.71,95.72 132.51,95.93 132,95.93 131.79,95.71 131.79,94.98 131.34,94.53 128.37,94.53 128.06,94.84 127.55,94.84 127.27,94.57 127.27,94.03 126.12,92.88 124.52,92.88 123.89,92.24 123.89,91.29 123.42,90.83 120.61,90.83 118.82,89.04 118.82,87.59 117.87,86.65 117.05,86.65 116.84,86.44 115.69,86.44 v1(115.27,86.03)
  BOTTOM w0.127: CPU1.N6 115.27,86.09 v1(115.27,86.03) ; v1(153.36,95.95) 152.85,96.46 152.85,97.34 153.37,97.86 154.53,97.86 155.11,97.28 173.58,97.28 174.24,96.62 174.62,96.62 175.03,96.21 184.9,96.21 185.74,95.38 189.77,95.38 194.08,91.07 194.08,89.82 193.36,89.1 193.36,87.16 192,85.8 192,83.16 192.74,82.42 v2(192.74,82.19) 192.74,79.39 192.38,79.04 192.32,79.04 191.54,78.26 R5607.2 192.29,77.05 U5601.4
SATA_PRX_ODDTX_N2: length 158.3
  L4 w0.114: v1(182.9,42.89) 182.67,43.12 181.92,43.12 180.54,44.5 163.74,44.5 163.61,44.63 163.61,44.63 162.11,46.13 148.65,46.13 141.28,53.49 141.28,55.9 139.93,57.26 139.93,59.4 139.55,59.78 139.55,74.4 138.44,75.51 138.44,86.72 139.55,87.82 139.55,90.92 139.04,91.42 139.04,92.65 138.45,93.25 138.45,94.76 138.6,94.92 138.6,98.19 137.34,99.45 129.97,99.45 128.03,97.5 124.74,97.5 122.77,95.53 120.47,95.53 119.35,94.41 119.35,93.81 118.01,92.47 118.01,91.7 117.44,91.13 116.83,91.13 115.29,89.59 115.29,89.29 v1(114.83,88.83)
  BOTTOM w0.127: v2(187.82,53.61) 187.69,53.61 ; 187.69,53.61 187.69,51.27 184.55,48.13 184.55,47.41 183.52,46.37 183.52,44.35 183.72,44.15 183.72,43.45 183.38,43.11 183.11,43.11 v1(182.9,42.89) ; 187.69,53.61 187.69,64.36 194.47,71.15 194.47,71.65 194.78,71.95 195.21,71.95 C5607.2 ; CPU1.J8 114.5,88.49 v1(114.83,88.83)
SATA_PRX_ODDTX_P2: length 158.4
  L4 w0.114: v1(182.85,43.7) 182.85,43.53 182.67,43.35 182.01,43.35 180.64,44.72 163.84,44.72 162.21,46.36 148.75,46.36 141.51,53.59 141.51,56 140.54,56.97 140.54,56.98 140.47,57.04 140.47,57.04 140.15,57.36 140.15,59.5 139.78,59.87 139.78,74.5 138.67,75.6 138.67,86.62 139.78,87.73 139.78,91.01 139.27,91.52 139.27,92.75 138.68,93.34 138.68,94.67 138.83,94.82 138.83,98.29 137.44,99.67 129.87,99.67 127.93,97.73 124.64,97.73 122.67,95.76 120.38,95.76 119.12,94.51 119.12,93.91 117.78,92.57 117.78,92.4 117.78,91.8 117.35,91.36 116.74,91.36 114.86,89.49 v1(114.85,89.49)
  BOTTOM w0.127: C5608.2 195.07,72.19 194.68,72.19 194.23,71.75 194.23,71.25 187.45,64.46 187.45,52.36 ; CPU1.H8 114.39,89.29 114.58,89.49 v1(114.85,89.49) ; 187.45,52.36 v2(187.32,52.36) ; 187.45,52.36 187.45,51.37 184.31,48.23 184.31,47.51 183.28,46.47 183.28,45.18 183.27,44.25 183.48,44.05 183.48,43.55 183.28,43.35 183.05,43.35 182.85,43.54 v1(182.85,43.7)
SATA_PTX_ODDRX_N2: length 158.3
  L4 w0.114: v1(110.82,97.64) 111.22,97.23 116.1,97.23 117.77,98.9 121.12,98.9 122.88,100.65 124.4,100.65 124.83,100.22 125.52,100.22 126.19,100.89 126.79,100.89 128.72,102.81 134.87,102.81 135.04,102.64 137.65,102.64 141.08,99.22 141.08,98.37 141.36,98.09 141.36,93.87 142.03,93.2 142.03,60.81 142.75,60.08 142.75,57.95 143.87,56.82 143.87,54.46 149.49,48.85 166,48.85 166.15,49.01 167.13,49.01 168.45,47.68 182.25,47.68 182.7,48.13 185.47,48.13 185.87,48.53 v1(185.87,48.61)
  BOTTOM w0.127: v1(185.87,48.61) 185.87,48.53 186.17,48.23 186.71,48.23 188.22,49.74 188.22,50.11 ; 188.22,50.11 188.22,64.1 194.35,70.23 195.14,70.23 C5611.2 ; 188.22,50.11 v2(188.1,50.11) ; CPU1.A17 109.31,93.83 109.31,95.91 109.7,96.29 109.7,96.98 110.1,97.38 110.56,97.38 v1(110.82,97.64)
SATA_PTX_ODDRX_P2: length 158.3
  L4 w0.114: v1(110.82,97) 116.19,97 117.87,98.67 121.22,98.67 122.97,100.42 124.31,100.42 124.74,99.99 125.62,99.99 126.28,100.66 126.88,100.66 128.81,102.58 134.78,102.58 134.95,102.41 137.56,102.41 140.85,99.12 140.85,98.28 141.13,98 141.13,93.78 141.8,93.1 141.8,60.71 142.52,59.99 142.52,57.85 143.64,56.72 143.64,54.37 149.39,48.62 166.09,48.62 166.25,48.78 167.03,48.78 168.36,47.45 182.35,47.45 182.79,47.9 185.87,47.9 v1(185.87,47.88)
  BOTTOM w0.127: v2(188.59,51.8) 188.46,51.8 ; 188.46,51.8 188.46,49.64 186.81,47.99 185.96,47.99 185.87,47.9 v1(185.87,47.88) ; 188.46,51.8 188.46,64 194.45,69.99 195.14,69.99 C5612.2 ; v1(110.82,97) 110.68,97.14 110.2,97.14 109.94,96.88 109.94,96.19 109.56,95.81 109.56,93.59 109.03,93.07 CPU1.B17
SATA_RCOMP: length 5.1
  BOTTOM w0.178: CPU1.C12 111.78,93.2 111.49,93.49 111.49,93.55 111.45,93.59 111.45,93.99 111.48,94.02
  BOTTOM w0.254: 111.48,94.02 111.75,94.29 111.75,95.62 v2(111.96,95.83)
  BOTTOM w0.508: R1906.1 112.77,96.64 v2(111.96,95.83)
SATA_RXN0_R: length 9.9
  BOTTOM w0.127: C5616.2 188.76,11 189.27,11 189.4,10.88 U5602.4 U5602.7 191.54,10.88 191.65,10.99 191.9,10.99 192.17,11.26 192.17,11.57 192.42,11.82 ; HDD1.S5 196.4,12.73 193.33,12.73 192.42,11.82 ; 192.42,11.82 v2(192.51,11.74)
SATA_RXN2_R: length 6.8
  BOTTOM w0.127: v2(198.5,71.89) 198.5,72.02 ; 198.5,72.02 198.77,72.02 199.84,73.09 201.76,73.09 ODD1.S5 ; 198.5,72.02 196.68,72.02 C5607.1
SATA_RXP0_R: length 9.9
  BOTTOM w0.127: HDD1.S6 196.37,12.98 193.49,12.98 ; C5615.2 188.82,11.24 189.29,11.24 189.4,11.36 U5602.5 U5602.6 191.48,11.36 191.61,11.23 191.8,11.23 191.93,11.36 191.93,11.67 193.23,12.98 193.49,12.98 ; 193.49,12.98 v2(193.49,13.1)
SATA_RXP2_R: length 6.8
  BOTTOM w0.127: v2(197.3,72.39) 197.3,72.26 ; 197.3,72.26 196.68,72.26 C5608.1 ; 197.3,72.26 198.67,72.26 199.74,73.33 201.71,73.33 ODD1.S6
SATA_TXN0_R: length 9.2
  BOTTOM w0.127: HDD1.S3 196.37,9.17 193.09,9.17 192.56,9.69 192.35,9.69 ; v2(192.35,9.81) 192.35,9.69 ; 192.35,9.69 191.64,9.69 191.49,9.83 U5602.9 U5602.2 189.4,9.83 189.16,9.6 188.73,9.6 C5603.1
SATA_TXN2_R: length 6.7
  BOTTOM w0.127: 197.46,70.19 196.71,70.19 C5611.1 ; 197.46,70.19 199.4,70.19 200.05,69.54 201.73,69.54 ODD1.S3 ; 197.46,70.19 v2(197.46,70.32)
SATA_TXP0_R: length 9.2
  BOTTOM w0.127: HDD1.S2 196.4,8.92 193.32,8.92 ; 193.32,8.92 v2(193.32,8.8) ; 193.32,8.92 192.99,8.92 192.46,9.45 191.64,9.45 191.55,9.36 U5602.10 U5602.1 188.88,9.36 C5602.1
SATA_TXP2_R: length 6.6
  BOTTOM w0.127: C5612.1 196.64,69.95 198.65,69.95 ; 198.65,69.95 v2(198.65,69.82) ; 198.65,69.95 199.3,69.95 199.95,69.3 201.74,69.3 ODD1.S2
SLEEVE: length 25.6
  TOP w0.203: v3(35.3,15.71) 35.83,15.18 HDA27.18
  TOP w0.305: RN2901.3 34.9,16.12 v3(35.3,15.71)
  TOP w0.508: R2911.2 23.79,3.83 EC2906.1 24.82,4.32 v3(25.13,4.63)
  L3 w1.016: v3(25.13,4.63) 23.85,5.92 23.85,10.52 27.15,13.82 28.89,13.82 30.3,15.23 34.81,15.23 v3(35.3,15.71)
  vias: v2(34.36,15.87)
SLEEVE_CTRL: length 4.9
  BOTTOM w0.254: R2915.2 29.85,18.99 30.09,18.75 U2901.6 28.73,18.13 28.57,17.98 v2(28.57,17.8) 28.57,17.62 28.71,17.48 U2901.5
SLEEVE_R: length 22.9
  TOP w1.016: HPMIC1.4 5.42,14.72 13.51,14.72 15.92,12.31 15.92,11.29 v2(18.74,8.48) 18.98,8.48 20.94,6.51 21.56,6.51
SM_DRAMRST#: length 17
  BOTTOM w0.089: CPU1.AV15 110.24,72.22 110.69,71.76 110.69,70.42
  BOTTOM w0.127: 110.69,70.42 110.69,69.28 110.53,69.12 110.53,67.35 110.23,67.06 110.23,64.61 112.09,62.76 v2(112.09,59.94) 112.09,59.34 112.87,58.56 R410.2 R404.1
SM_INTRUDER#: length 11.5
  TOP w0.102: R1901.2 118.06,63.28 118.06,64.66 117.75,64.97 117.75,66.58 117.29,67.04 117.29,67.66 116.92,68.03 116.92,69.01 v2(116.62,69.32) 116.08,69.86 v1(116.02,69.86)
  BOTTOM w0.089: 115.95,70.57 115.8,70.71 115.8,72.22 115.84,72.26 115.84,72.75 CPU1.AU6
  BOTTOM w0.102: 115.95,70.57 116.02,70.49 v1(116.02,69.86)
SM_RCOMP_0: length 2.8
  TOP w0.508: R407.2 82.33,75.14 81.77,74.58 v2(81.77,74.22) 81.77,73.87 v1(82.04,73.59)
  BOTTOM w0.305: v1(82.04,73.59) 82.33,73.31 CPU1.AU60
SM_RCOMP_1: length 4.4
  TOP w0.508: v1(81.84,72.22) 81.3,72.75 81.3,72.76 v2(81.29,72.78) 80.88,73.19 80.88,74.73 R408.2
  BOTTOM w0.305: CPU1.AV60 82,72.39 v1(81.84,72.22)
SM_RCOMP_2: length 6.4
  BOTTOM w0.203: 78.38,72.36 78.94,72.36 79.86,73.27 80.01,73.42 81.05,73.42 81.16,73.31 CPU1.AU61
  BOTTOM w0.508: R409.2 77.05,72.55 v2(77.21,72.38) 77.24,72.36 78.38,72.36
SMB_CLK: length 21.3
  TOP w0.14: v1(131.49,74.55) 131.57,74.55 v2(131.95,74.92)
  L4 w0.127: v1(120.79,73.35) 120.91,73.47 121.84,73.47 123.46,75.09 124,75.09 124.44,75.53 126.21,75.53 127.73,74.01 127.73,72.46 128.5,71.7 v1(129.39,71.7) 129.51,71.7 130.15,72.33 130.15,73.21 v1(131.49,74.55)
  BOTTOM w0.089: CPU1.AP2 118.53,74.22 119.29,74.22 119.45,74.06
  BOTTOM w0.14: v1(129.39,71.7) 129.42,71.73 Q1801.3 ; v1(131.49,74.55) 131.87,74.16 RN1811.3 ; 119.45,74.06 119.58,73.93 120.21,73.93 v1(120.79,73.35)
SMB_DATA: length 26.3
  TOP w0.14: v2(122.81,77.44) 122.45,77.08 v1(122.45,76.86)
  L4 w0.127: v1(131.47,75.31) 131.47,75.25 129.62,73.39 129.62,73.26 v1(129.41,73.06) 128.43,73.06 128.24,73.25 128.24,74.22 126.42,76.04 124.23,76.04 123.79,75.59 123.25,75.59 121.66,74.01 120.6,74.01 120.37,74.24 120.37,74.97 120.75,75.35 120.75,76.27 120.72,76.29 120.72,76.58 120.97,76.83 121.32,76.83 121.46,76.68 121.81,76.68 121.99,76.86 v1(122.45,76.86)
  BOTTOM w0.14: RN1811.4 131.96,74.82 v1(131.47,75.31) ; v1(122.45,76.86) 122.45,76.92 122.08,77.3 122.06,77.3 121.77,77.58 121.42,77.58 120.77,78.23 120.17,78.23 120.17,78.23 118.92,78.23 CPU1.AH1 ; v1(129.41,73.06) 129.39,73.03 Q1801.6
SMBC_THERM_NV: length 22.6
  TOP w0.14: v1(175.78,110.84) 175.78,110.62 176.49,109.91 177.62,109.91 178.06,109.46 179.49,109.46 179.97,109.94 ; 179.97,109.94 180.45,110.42 180.45,111.1 v1(180.97,111.62) 181.12,111.77 181.36,111.77 181.75,112.16 181.75,113.49 182.2,113.94 RN7601.2 ; 179.97,109.94 v2(180.09,109.81)
  L4 w0.127: v1(180.97,111.62) 181.46,111.62 182,112.16 183.15,112.16 183.9,112.9 188.02,112.9 189.24,114.11 v1(190.02,114.11)
  BOTTOM w0.14: GPU1.D9 175.79,110.91 175.79,110.85 v1(175.78,110.84) ; v1(190.02,114.11) 190.7,114.8 Q7601.1
SMBD_THERM_NV: length 25.2
  TOP w0.14: RN7601.1 182.11,114.59 181.23,113.71 181.23,112.38 v1(181.14,112.29) 180.9,112.29 179.93,111.32 179.93,110.64 179.28,109.98 178.28,109.98 177.83,110.43 176.99,110.43 176.6,110.82 v1(176.55,110.82)
  L4 w0.127: v1(181.14,112.29) 181.14,112.3 181.14,112.37 181.44,112.66 182.94,112.66 183.68,113.4 187.81,113.4 189.4,114.99 189.57,114.99 v1(191.64,117.06)
  BOTTOM w0.14: Q7601.4 192.61,116.1 v1(191.64,117.06) 191.56,117.06 v2(190.9,117.72) ; GPU1.D8 176.15,110.45 176.53,110.82 v1(176.55,110.82)
SML0_CLK: length 15.7
  TOP w0.14: v1(131.52,76.36) 131.99,76.36 v2(132.26,76.62)
  L4 w0.127: v1(121.41,74.91) 121.41,74.95 121.82,75.36 122.43,75.36 123.04,75.98 123.63,75.98 124.22,76.57 127.14,76.57 127.73,77.16 128.54,77.16 129.3,76.39 131.49,76.39 v1(131.52,76.36)
  BOTTOM w0.127: CPU1.AN1 119.01,75.25 119.1,75.16 119.62,75.16
  BOTTOM w0.14: v1(121.41,74.91) 121.24,75.07 120.65,75.07 120.56,75.16 119.62,75.16 ; RN1807.5 131.89,76.34 131.87,76.36 v1(131.52,76.36)
SML0_DATA: length 16.1
  TOP w0.14: v2(120.75,77.03) 121.14,76.64 v1(121.14,76.41)
  L4 w0.127: v1(121.14,76.41) 121.68,75.87 122.22,75.87 122.83,76.48 123.42,76.48 124.01,77.08 126.93,77.08 127.52,77.67 128.75,77.67 129.51,76.9 131.35,76.9 v1(131.44,76.99)
  BOTTOM w0.127: CPU1.AK1 119.23,77.5 119.36,77.63 119.92,77.63 v1(121.14,76.41)
  BOTTOM w0.14: RN1807.6 131.44,76.99 v1(131.44,76.99)
SML1_CLK: length 201.7
  TOP w0.14: v1(129.6,57.4) 129.42,57.57 128.67,57.57 v2(128.42,57.83) 128.42,57.74 127.96,57.28 127.25,57.28 126.81,56.83 125.55,56.83 125.25,57.14 Q2601.3 ; KBC24.67 163.01,35.3 163.24,35.53 163.24,35.54 v1(163.29,35.58)
  L3 w0.127: v1(129.6,57.4) 129.72,57.4 129.78,57.34 130.25,57.34 130.65,57.74 130.65,61.81 131.35,62.51 131.35,66.13 130.99,66.49 130.32,66.49 128.37,68.44 128.37,70.43 128.9,70.96 129.48,70.96 130.38,71.86 130.38,77.29 131.23,78.14 131.42,78.14 v1(131.55,78.27) ; v1(178.97,45.97) 183.21,50.22 183.21,56.07 185.25,58.11 185.25,61.4 187.83,63.97 187.83,85.03 188.2,85.4 188.2,95 185.61,97.59 185.61,101.71 186.16,102.25 186.16,103.44 187.81,105.09 187.81,109.15 191.28,112.62 191.28,113.41 v1(191.21,113.48)
  L4 w0.127: v1(119.76,72.21) 119.58,72.21 119.02,72.76 119.02,74.54 119.5,75.02 119.72,75.02 120.53,75.83 120.53,76.18 120.51,76.2 120.51,76.7 121.12,77.32 121.77,77.96 125.22,77.96 126.75,79.49 128.98,79.49 130.53,77.95 131.07,77.95 131.39,78.27 v1(131.55,78.27) ; v1(129.6,57.4) 130.22,57.4 130.95,56.68 130.95,56.15 133.67,53.43 133.67,50.4 134.13,49.95 135.02,49.95 140.17,44.79 141.59,44.79 144.57,41.8 145.06,41.8 146.79,40.07 147.51,40.07 148.11,39.48 148.81,39.48 150.49,37.8 152.95,37.8 154.17,36.58 156.91,36.58 156.98,36.51 157.41,36.51 157.49,36.58 v1(157.62,36.58)
  BOTTOM w0.089: CPU1.AU3 117.88,72.77 118.57,72.77 118.62,72.72 119.08,72.72 119.24,72.56
  BOTTOM w0.127: 119.55,72.26 119.24,72.56
  BOTTOM w0.14: RN1807.8 131.68,78.14 v1(131.55,78.27) ; v1(178.97,45.97) 179.18,45.76 179.18,45.47 178.6,44.89 176.49,44.89 175.52,45.86 167.86,45.86 165.35,43.35 165.35,42.66 163.78,41.1 163.78,38.32 164.14,37.97 164.14,35.81 163.76,35.43 163.44,35.43 v1(163.29,35.58) 163.09,35.38 160.25,35.38 159.1,36.53 157.67,36.53 v1(157.62,36.58) ; v1(119.76,72.21) 119.6,72.21 119.55,72.26 ; v1(191.21,113.48) 191.34,113.61 191.36,113.61 192.55,114.8 Q7601.6
SML1_DATA: length 197
  TOP w0.14: Q2601.6 126.91,56.15 v2(127.79,56.15) 127.79,56.37 128.47,57.05 129.21,57.05 129.38,56.88 129.59,56.88 v1(129.79,56.69) ; v1(163.29,34.82) 163.21,34.9 KBC24.68
  L3 w0.127: v1(131.53,77.63) 131.44,77.63 130.88,77.08 130.88,71.65 129.69,70.45 129.11,70.45 128.88,70.22 128.88,68.65 130.53,67 131.2,67 131.86,66.34 131.86,62.3 131.16,61.6 131.16,57.53 130.46,56.83 129.93,56.83 v1(129.79,56.69) ; v1(180.05,45.97) 179.98,46.05 179.98,46.26 183.72,50.01 183.72,55.86 185.76,57.9 185.76,61.19 188.34,63.76 188.34,84.82 188.71,85.19 188.71,95.21 186.12,97.8 186.12,101.5 186.66,102.04 186.66,103.23 188.31,104.88 188.31,108.94 191.79,112.41 191.79,113.69 191.35,114.13 v1(191.14,114.13)
  L4 w0.127: v1(131.53,77.63) 131.34,77.44 130.32,77.44 128.77,78.99 126.96,78.99 125.43,77.46 121.99,77.46 v1(121.64,77.1) ; v1(157.63,35.92) 157.5,35.92 157.42,36 156.77,36 156.7,36.07 153.96,36.07 152.74,37.29 150.28,37.29 148.6,38.97 147.9,38.97 147.3,39.57 146.58,39.57 144.85,41.3 144.36,41.3 141.37,44.28 139.96,44.28 134.81,49.44 133.92,49.44 133.16,50.19 133.16,53.22 130.44,55.94 130.44,56.47 130.25,56.65 129.82,56.65 v1(129.79,56.69)
  BOTTOM w0.089: 120.27,78 119.2,78 119.16,77.97 118.02,77.97 117.77,78.21 CPU1.AH3
  BOTTOM w0.14: Q7601.3 191.59,116.1 191.72,115.97 191.72,114.7 v1(191.14,114.13) ; v1(157.63,35.92) 157.73,36.01 158.88,36.01 160.03,34.86 163.22,34.86 163.27,34.82 v1(163.29,34.82) 163.39,34.91 163.98,34.91 164.66,35.6 164.66,38.18 164.3,38.54 164.3,40.88 165.87,42.44 165.87,43.13 168.07,45.34 175.31,45.34 176.28,44.37 178.82,44.37 179.7,45.25 179.7,45.62 v1(180.05,45.97) ; 120.27,78 120.68,78 121.58,77.1 121.63,77.1 v1(121.64,77.1) ; v1(131.53,77.63) 131.67,77.49 RN1807.7
SP_PLLVDD: length 1.2
  BOTTOM w0.356: v1(169.08,109.14) GPU1.M6 ; v1(169.11,108.32) 169.1,108.32 GPU1.N6
  vias: v2(169.11,105.15)
SPI_CLK_R: length 101.2
  TOP w0.14: R2420.1 157.1,23.28 v1(156.94,23.44)
  L3 w0.127: v1(124.55,83.64) 125.18,83.64 125.8,84.27 126.54,84.27 127.36,83.45 127.36,81.2 128.78,79.78 132,79.78 132.81,78.97 133.25,78.53 133.25,71.51 137.68,67.08 137.68,49.55 145.7,41.53 145.7,39.48 148.68,36.5 148.68,34.07 149.72,33.03 v1(149.72,31.27) 150.15,30.84 151,30.84 153.71,28.14 153.71,27.65 156.37,24.98 156.37,24.01 v1(156.94,23.44)
  BOTTOM w0.14: 150.2,31.75 150.3,31.85 151.94,31.85 155.2,35.11 155.2,36 155.85,36.65 155.85,37.75 156.22,38.13 EC2503.1 156.22,42.9 153.74,45.38 SKT25.6 ; 150.2,31.75 v1(149.72,31.27) ; 150.2,31.75 v2(150.07,31.87) ; R1806.1 122.87,82.57 123.59,83.29 124.2,83.29 v1(124.55,83.64)
SPI_CS0#_R: length 100.4
  TOP w0.14: v1(125.42,91.54) 124.97,91.09 124.97,89.86 123.7,88.58 R1807.1 ; R2419.1 157.01,24.17 v1(156.94,24.1)
  L3 w0.127: v1(125.42,91.54) 125.42,91.54 125.42,91.54 126.88,91.54 128.44,89.98 128.44,87.48 128.26,87.31 128.26,84.79 128.88,84.17 128.88,82.66 129.89,81.65 130.58,81.65 130.74,81.82 132.12,81.82 134.78,79.16 134.78,72.93 139.3,68.41 139.3,50.24 147.23,42.31 147.23,40.11 150.2,37.13 150.2,35.29 v1(150.28,35.21) 151.14,34.34 151.14,31.8 154.46,28.49 154.68,28.49 155.11,28.05 155.11,27.49 157.36,25.24 157.36,24.53 v1(156.94,24.1)
  BOTTOM w0.14: v1(150.28,35.21) 150.04,35.45 v2(149.22,35.45) 147.93,35.45 147.37,36.01 147.37,38.49 R2501.1 146.69,40.89 147.39,41.59 147.39,42.55 147.11,42.84 SKT25.1
SPI_HOLD#: length 81.7
  TOP w0.14: v1(124.86,84.27) 125.17,83.96 R1812.1
  L3 w0.127: v1(150.7,34.14) 150.51,33.95 149.88,33.95 149.44,34.39 149.44,36.82 146.46,39.79 146.46,42 138.44,50.02 138.44,68.17 134.01,72.6 134.01,78.85 132.32,80.55 131.68,80.55 131.68,80.55 129.09,80.55 128.12,81.52 128.12,83.85 126.55,85.42 126.17,85.42 125.02,84.27 v1(124.86,84.27)
  BOTTOM w0.14: SPI25.7 150.91,44.14 150.14,43.37 150.14,41.23 150.36,41.02 150.36,41.01 150.62,40.75 152.39,38.98 v2(152.39,38.6) RN2501.2 152.39,36.88 152.16,36.65 151.56,36.65 151.17,36.27 151.17,34.62 v1(150.7,34.14)
SPI_SI_R: length 100.3
  TOP w0.14: R2422.1 157.22,25.06 v1(156.92,24.76)
  L3 w0.127: v1(156.92,24.76) 156.92,24.97 154.09,27.8 154.09,28.3 151.1,31.28 v1(150.42,31.28) 150.1,31.6 150.1,33.19 149.06,34.23 149.06,36.66 146.08,39.63 146.08,41.74 138.06,49.76 138.06,67.24 133.63,71.66 133.63,78.69 132.97,79.35 132.16,80.17 131.84,80.17 128.93,80.17 127.74,81.36 127.74,83.61 v1(126.37,84.98)
  BOTTOM w0.14: 155.94,36.15 156.27,36.48 156.27,37.58 EC2501.1 156.64,38.89 156.64,43.07 154.16,45.55 154.16,46.56 154.04,46.68 SPI25.5 ; 155.94,36.15 v2(156.04,36.05) ; 155.94,36.15 155.62,35.83 155.62,34.93 152.12,31.43 150.56,31.43 v1(150.42,31.28) ; v1(126.37,84.98) 126.13,84.74 R1808.1
SPI_SO_R: length 87.5
  TOP w0.14: R2423.1 157.13,25.96 155.9,24.73 v1(155.57,24.73)
  L3 w0.127: v1(155.57,24.73) 155.57,25.24 153.32,27.49 153.32,27.98 150.85,30.46 149.89,30.46 149.12,31.23 149.12,33.09 148.23,33.98 v1(148.23,36.02) 148.22,36.03 148.22,36.42 145.32,39.32 145.32,41.37 137.3,49.39 137.3,66.92 132.87,71.35 132.87,78.37 131.85,79.4 128.63,79.4 126.98,81.04 126.98,83.29 126.44,83.82 v1(126.17,83.82)
  BOTTOM w0.14: SKT25.2 147.36,44.11 147.89,43.57 EC2502.1 v2(147.89,37.61) 147.89,36.37 148.23,36.03 v1(148.23,36.02) ; v1(126.17,83.82) 125.86,83.51 R1809.1
SPI_WP#: length 90.8
  TOP w0.14: R1811.1 124.53,86.19 v2(124.53,88.71) 124.53,88.82 125.41,89.7 125.41,90.88 v1(125.42,90.89)
  L3 w0.127: v1(149.98,34.48) 149.82,34.64 149.82,36.97 146.84,39.95 146.84,42.16 138.92,50.08 138.92,68.25 134.4,72.78 134.4,79.01 131.97,81.44 131.22,81.44 131.06,81.27 128.91,81.27 128.5,81.68 128.5,84.01 127.88,84.63 127.88,87.47 128.06,87.64 128.06,89.82 126.99,90.89 v1(125.42,90.89)
  BOTTOM w0.14: v1(149.98,34.48) 150.26,34.48 150.75,34.97 150.75,36.54 151.4,37.19 RN2501.1 151.74,37.81 151.84,37.91 151.84,38.93 150.45,40.33 150.45,40.33 149.72,41.05 149.72,43.16 147.5,45.38 SKT25.3
SRTC_RST#: length 11
  TOP w0.127: RN1901.4 118.75,64.66 C1902.1 117.99,65.41 117.99,66.68 117.53,67.14 v2(117.53,68.19) 117.53,70.05 115.5,72.08 v1(115.14,72.08)
  BOTTOM w0.089: CPU1.AV6 115.25,72.08 v1(115.14,72.08)
STRAP0: length 6.6
  BOTTOM w0.127: v2(176.36,98.85) 176.45,98.95 R7646.2 176.36,99.78 R7625.2 175.53,101.43 R7621.1 175.53,101.7 176.22,102.39 176.22,104.62 GPU1.D1
STRAP1: length 6.5
  BOTTOM w0.127: R7635.2 173.8,101.41 R7622.1 173.84,102.27 174.32,102.27 v2(174.55,102.5) 175.79,103.75 175.79,104.98 176.15,105.33 GPU1.D2
STRAP2: length 5.3
  TOP w0.127: v2(173.94,106.11) 173.64,106.41 173.64,106.88 173.89,107.13 174.46,107.13 v1(174.84,107.5) 174.92,107.5 175.35,107.94 R7606.2 175.82,107.94 R7637.1
  BOTTOM w0.102: GPU1.E4 174.9,107.49 174.85,107.49 v1(174.84,107.5)
STRAP3: length 37.2
  TOP w0.127: v1(172.97,102.1) 173.66,102.1 174.24,102.67 174.24,103.25 173.81,103.68 173.81,105.39 174.74,106.31 174.78,106.31 175.55,107.08 177.14,107.08 178.98,105.24 179.89,105.24 180.39,105.74 182.9,105.74 183.06,105.58 185.18,105.58 186.69,107.09 186.69,108.41 187.55,109.26 v2(187.55,110.33) 187.55,111.72 v1(188.54,112.72)
  BOTTOM w0.102: GPU1.E3 175.3,106.1 175.71,105.69
  BOTTOM w0.127: R7615.2 187.48,113.52 188.29,112.72 v1(188.54,112.72) ; 175.71,105.69 175.78,105.62 175.78,105.29 175.57,105.07 175.57,103.84 175.04,103.32 173.7,103.32 173.4,103.02 173.4,102.53 v1(172.97,102.1) 172.51,102.56 171.52,102.56 171.21,102.24 R7609.1
STRAP4: length 8.2
  BOTTOM w0.127: GPU1.D3 176.34,106.1 176.34,106.03 176.51,105.87 176.51,104.34 176.67,104.18 176.67,102.17 176.33,101.83 R7632.1 176.33,100.73 R7634.2 176.45,100.6 177.06,99.99 177.06,99.54 v2(177.63,98.98)
STRAP_REF0_GND_N9: length 2.4
  TOP w0.127: v1(174.06,109.18) 174.28,108.96 R7607.2 174.28,107.83 v2(173.99,107.54)
  BOTTOM w0.102: GPU1.F6 v1(174.06,109.18)
SUS_CLK: length 85.5
  L3 w0.127: v1(131.04,87.81) 131.04,87.87 131.53,88.36 131.9,88.36 132.35,87.92 132.35,86.33 132.52,86.16 132.52,85.81 134.49,83.85 136.57,83.85 138.95,81.46 138.95,76.15 143.64,71.46 143.64,61.7 148.33,57.02 149.45,57.02 150.04,56.43 150.04,55.31 151.07,54.28 151.07,53.96 161.72,43.31 161.72,39.51 162.72,38.51 163.32,38.51 165.04,36.78 169.45,36.78 171.87,34.36 173.07,34.36 174.19,33.25 v1(174.19,32.86)
  BOTTOM w0.14: R1710.2 131.04,88.04 v1(131.04,87.81) ; v1(174.19,32.86) 173.1,32.86 172.82,33.14 172.56,33.14 171.7,33.14 v2(171.27,32.71) 171.24,32.68 R2441.2
SUS_CLK_PCH: length 21.5
  L4 w0.127: v1(129.28,89.36) 129.09,89.36 128.58,88.85 128.58,87.43 126.58,85.42 125.98,85.42 125.92,85.36 124.95,85.36 122.28,82.69 120.31,82.69 120.22,82.6 119.33,82.6 117.4,80.66 116.24,80.66 v1(115.8,80.23)
  BOTTOM w0.14: v1(115.8,80.23) 115.8,79.95 CPU1.AE6 ; v1(129.28,89.36) v2(129.28,89.93) 129.98,89.93 EC1701.2 130.72,89.2 R1710.1
SUSCLK_KBC: length 7.2
  TOP w0.14: v1(165.24,32.42) 164.74,31.92 163.74,31.92 163.11,31.3 KBC24.77
  BOTTOM w0.14: R2441.1 v2(167.43,32.68) 165.5,32.68 v1(165.24,32.42)
SYS_PEX_RST_MON#: length 48.5
  TOP w0.127: D7301.2 156.29,104.49 155.2,103.4 155.2,102.5 v1(155.64,102.06) 155.47,101.89 R7304.2 155.18,100.99 R7306.1 154.45,100.99 153.78,101.65 U7301.4 ; v1(181.23,104.7) 181.02,104.7 177.45,101.13 177.45,100.13 177.3,99.98 177.3,99.4 178.61,98.09 179.76,98.09 180.56,97.28 180.56,96.91 180.3,96.65 179.36,96.65 176.82,99.2 176.82,99.69 176.47,100.04 175.58,100.04 175.35,100.27 174.74,100.27 174.5,100.51 167.52,100.51 166.96,101.07 166.02,101.07 165.89,101.21 v2(165.86,101.21) 165.86,101.24 v1(165.17,101.92)
  BOTTOM w0.127: v1(165.17,101.92) 155.78,101.92 v1(155.64,102.06) ; R7313.1 182.5,103.86 R7629.2 181.23,104.6 v1(181.23,104.7)
SYS_PEX_RST_MON_GPU#: length 11.7
  TOP w0.127: v1(180.78,107.2) 179.16,108.82 178.21,108.82 177.36,109.67 176.01,109.67 v2(175.71,109.97) 175.36,110.33 175.36,111.01 175.76,111.41 v1(175.76,111.65)
  BOTTOM w0.127: GPU1.E9 175.38,111.27 v1(175.76,111.65) ; v1(180.78,107.2) 181.04,106.94 181.04,106.87 181.17,106.74 181.17,106.21 R7643.1 181.96,105.42 R7629.1
SYS_PWROK: length 100.9
  TOP w0.127: v1(165.21,30.16) 164.95,29.91 164.57,29.91 163.15,28.5 KBC24.84
  L3 w0.127: v1(129.56,90.47) 129.74,90.29 129.74,87.13 129.98,86.89 129.98,85.71 v1(131.06,84.62) 131.53,84.15 131.53,83.99 132.96,82.56 134.11,82.56 137.47,79.21 137.47,75.33 142.16,70.64 142.16,53.84 152.27,43.73 152.27,41.99 156.57,37.69 156.57,36.35 157.45,35.47 159.11,35.47 162.09,32.49 163.21,32.49 164.17,31.53 164.78,31.53 165.21,31.1 v1(165.21,30.16)
  L4 w0.127: v1(131.06,84.62) 130.35,84.62 129.1,83.38 127.31,83.38 126.29,82.35 124.79,82.35 123.7,81.26 122.7,81.26 122.53,81.09 122.13,81.09 120.98,79.95 120.56,79.95 120.08,79.47 v1(120.08,78.97)
  BOTTOM w0.089: CPU1.AG2 118.39,79 118.68,78.71 119.12,78.71 119.22,78.61 119.72,78.61 v1(120.08,78.97)
  BOTTOM w0.127: v2(165.84,30.16) 165.21,30.16 v1(165.21,30.16) ; R9605.1 131.21,92.32 R1717.1 EC1702.1 129.68,90.58 v1(129.56,90.47)
T_CRIT#: length 4
  TOP w0.102: R2604.2 R2601.1 113.32,109.06 113.97,109.06 114.01,109.02 v2(114.02,109.02) 114.95,109.02 115.11,109.18 THM26.4
TD_IREF: length 4.3
  BOTTOM w0.102: R603.2 111.88,96.94 111.37,96.43 111.37,94.41 111.17,94.21 111.17,93.53 111.25,93.45 111.25,93.25 CPU1.B12
TESTMODE: length 8.2
  BOTTOM w0.102: GPU1.AD9 159.12,111.7 157.8,111.7 157.58,111.92 157.58,112.37 155.37,114.59 v2(154,114.59) 153.81,114.4 R7302.1
THERM_SYS_SHDN#: length 141
  TOP w0.102: v1(157.3,21.3) 157.67,21.66 Q2602.S 156.89,22.06 156.59,21.76 156.59,20.57 156.4,20.39 155.14,20.39 154.27,21.26 153.15,21.26 152.44,21.97 151.35,21.97 149.86,23.46 149.86,27.83 149.29,28.4 149.29,35.1 149.6,35.42 149.6,40.43 146.23,43.81 146.23,53.04 v2(146.23,53.04) 146.23,55.01 146.19,55.05 146.19,55.78 v1(146.56,56.15) ; v1(112.57,108.62) 112.23,108.96 R2601.2
  L3 w0.102: v1(157.3,21.3) 157.78,21.77 161.36,21.77 161.66,21.48 166.51,21.48 v1(166.98,21.01)
  L4 w0.102: v1(112.57,108.62) 123.15,108.62 124.62,107.15 138.19,107.15 141.42,103.92 141.42,101.7 143.08,100.05 143.08,99.2 143.36,98.92 143.36,94.7 144.03,94.03 144.03,61.63 144.92,60.74 144.92,60.19 146.56,58.55 v1(146.56,56.15)
  BOTTOM w0.102: R2602.1 169.23,22.74 167.5,21.01 v1(166.98,21.01)
