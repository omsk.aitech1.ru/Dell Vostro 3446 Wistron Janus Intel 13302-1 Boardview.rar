# Allegro board Janus Intel MB_13302-1.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
1D05V_S0 on BOTTOM: 145.74,102.05 145.11,102.68 145.11,111.27 143.89,112.48 143.89,122.33 145,123.44 146.67,123.44 146.76,123.53 149.55,123.53 149.76,123.32 149.76,121.78 149.65,121.67 148.78,121.67 148.59,121.48 148.59,120.36 148.13,119.9 148.13,112.53 148.95,111.71 148.95,103.86 148.28,103.19 148.28,102.56 147.77,102.05
1D05V_S0 on L2VCC: 107.85,79.63 105.93,81.55 105.93,89.54 108.36,89.54 108.85,90.03 108.85,91.97 107.71,93.11 107.71,94.64 106.96,95.38 105.29,95.38 105.29,99.83 106.96,99.83 109.1,101.97 109.1,104.13 111.4,106.43 120.77,106.43 122.04,105.16 127.25,105.16 127.52,104.89 127.52,99.97 126.61,99.06 118.49,99.06 112.28,92.86 112.28,80.16 111.75,79.63
1D05V_S0 on L3: 107.93,79.63 105.61,81.96 105.61,98.93 108.22,101.55 108.22,103.31 111.55,106.64 120.81,106.64 122.03,105.42 146.32,105.42 146.85,104.89 146.85,102.62 146.37,102.13 144.45,102.13 143.34,101.03 136.48,101.03 136.47,101.04 131.55,101.04 131.24,101.34 125.02,101.34 123.06,99.38 119.33,99.38 119.3,99.35 117.32,99.35 117.04,99.07 116.94,99.07 113.62,95.75 112.35,95.75 110.28,93.68 110.28,91.6 110.6,91.28 110.6,88.57 110.89,88.28 110.89,85.87 112.05,84.71 112.05,80.21 111.82,79.99 111.23,79.99 110.88,79.63 ; 1 cut-out
1D05V_VGA_OUT2 on TOP: 151.71,121.57 151.66,121.62 151.66,122.18 151.39,122.45 151.39,124.79 151.44,124.84 154.62,124.84 154.72,124.75 154.72,122.45 154.61,122.34 153.45,122.34 152.67,121.57
1D05V_VGA_S0 on TOP: 161.26,112.21 161.16,112.31 161.16,114.04 161.24,114.11 162.15,114.11 162.33,113.94 162.33,112.36 162.18,112.21
1D05V_VGA_S0 on TOP: 155.8,116.55 155.03,117.32 155.03,117.32 154.74,117.61 154.74,121.98 155,122.25 155,128.56 156.1,129.65 162.57,129.65 162.77,129.46 162.77,125.49 162.1,124.82 162.1,124.82 161.87,124.59 161.87,121.5 161.24,120.87 161.24,120.51 161.41,120.34 161.8,120.34 161.85,120.39 162.94,120.39 162.99,120.34 162.99,117.62 162.84,117.47 161.11,117.47 160.47,118.1 160.47,119.37 160.22,119.63 160.22,120.64 159.84,121.02 157.27,121.02 156.99,120.75 156.99,119.64 157.24,119.39 157.24,116.83 156.96,116.55 ; 24 cut-outs
1D05V_VGA_S0 on BOTTOM: 161.49,111.88 161.24,112.13 161.24,112.77 161.49,113.02 161.49,114.55 162.25,115.31 162.25,116.33 161.49,117.09 161.49,117.85 161.36,117.98 161.36,120.39 161.49,120.52 161.49,121.28 160.51,122.26 153.39,122.26 153.18,122.47 153.18,125.16 153.34,125.31 155.45,125.31 156.45,124.31 158.17,124.31 158.31,124.45 158.31,124.63 158.04,124.91 157.86,124.91 157.55,125.22 157.55,126.15 157.75,126.35 158.83,126.35 159.2,125.98 159.2,125.22 160.6,123.82 160.6,123.56 160.47,123.44 160.47,123.18 160.6,123.06 160.98,123.06 161.11,123.18 161.36,123.18 161.49,123.06 161.49,122.8 161.36,122.68 161.36,122.42 161.62,122.17 161.74,122.17 161.87,122.29 162.25,122.29 162.38,122.17 162.38,121.41 163.14,120.64 163.14,119.5 162.89,119.25 162.89,112.13 162.63,111.88 ; 1 cut-out
1D05V_VGA_S0 on L3: 162.44,119.06 162.44,117.26 162.84,116.87 162.84,103.85 162.68,103.7 161.41,103.7 161.17,103.95 161.17,112.03 161.26,112.12 161.26,114.29 159.13,116.41 155.67,116.41 155.09,117 155.09,119.3 154.79,119.6 154.79,120.31 155.67,121.2 160.7,121.2 161.39,121.89 161.8,121.89 162,121.68 162,121.4 161.67,121.07 161.47,121.07 161.26,120.87 161.26,120.46 161.41,120.31 161.67,120.31 161.9,120.08 161.9,119.6
1D35V_PWR on TOP: 80.55,14.63 80.55,14.63 78.65,14.63 77.44,15.85 77.44,18.12 77.72,18.4 84.45,18.4 84.62,18.23 84.62,14.96 84.28,14.63 ; 6 cut-outs
1D35V_PWR on BOTTOM: 105.96,12.98 105.79,13.16 105.79,13.93 106.29,14.43 108.04,14.43 108.29,14.18 108.29,13.18 108.09,12.98 ; 2 cut-outs
1D35V_PWR on BOTTOM: 77.42,12.77 76.91,13.28 76.91,18.42 87.01,18.42 87.32,18.1 87.32,12.9 87.2,12.77 81.05,12.77 81.04,12.78 81.03,12.77
1D35V_PWR on L4: 83.18,18.05 77.7,18.05 77.39,17.75 77.39,16.07 77.59,15.87 83.26,15.87 85.42,18.03 85.42,18.53 85.11,18.84 83.97,18.84
1D35V_PWR on L4: 109.55,15.56 108.53,15.56 106.88,13.91 106.88,13.02 107.26,12.64 108.4,12.64 109.8,14.04 109.8,15.31
1D35V_S3 on TOP: 70.15,18.77 67.26,21.66 67.26,26.61 67.04,26.83 67.04,45.48 67.32,45.77 68.37,45.77 68.56,45.96 68.56,47.23 67.78,48 67.78,51.75 67.89,51.86 68.65,51.86 76.65,59.86 76.65,66.82 76.8,66.97 77.9,66.97 78.42,66.45 78.9,66.45 84.59,72.14 87.39,72.14 88.93,73.68 88.93,79.07 89.51,79.65 100.23,79.65 100.68,79.19 100.68,78.86 100.91,78.63 100.91,78.12 100.73,77.94 100.73,77.61 100.96,77.39 101.34,77.39 101.9,77.94 101.9,79.11 102.16,79.37 103.15,79.37 103.27,79.24 103.27,79.01 102.89,78.63 102.89,78.17 103.58,77.49 103.58,68.9 103.59,68.89 103.59,57.02 104.28,56.33 116.41,56.33 119.45,53.29 130.41,53.29 131.62,54.5 137.11,54.5 137.47,54.14 137.47,45.5 136.72,44.75 123.92,44.75 115.18,36.01 91.03,36.01 90.61,35.58 90.61,30.3 90.3,30 90.3,26.72 90.41,26.61 90.41,26.08 90.26,25.93 87.95,25.93 87.37,26.51 87.02,26.51 86.76,26.26 86.76,23.36 88.47,21.66 88.47,20.52 86.72,18.77 ; 18 cut-outs
1D35V_S3 on BOTTOM: 75.13,18.74 74.88,18.99 74.88,21.53 75,21.66 89.61,21.66 89.74,21.53 89.74,21.28 87.2,18.74
1D35V_S3 on BOTTOM: 135.46,48.33 134.92,48.88 134.92,54.51 135.26,54.85 171.05,54.85 171.31,55.11 176.86,55.11 177.05,54.92 177.05,49.79 176.84,49.57 176.83,49.57 176.3,49.04 169.16,49.04 168.93,49.27 168.63,49.27 168.08,48.72 157.53,48.72 157.15,48.33 ; 2 cut-outs
1D35V_VGA_EN# on BOTTOM: 181.33,52.71 181.22,52.82 181.22,53.84 181.31,53.94 184.25,53.94 184.79,54.48 184.79,54.93 184.79,55.44 185.07,55.72 186.04,55.72 186.26,55.5 186.26,53.41 186.13,53.28 185.62,53.28 185.39,53.05 182.92,53.05 182.57,52.71 ; 1 cut-out
1D35V_VGA_S0 on TOP: 173.07,114.13 172.94,114.26 172.94,115.52 172.66,115.8 172.09,115.8 171.92,115.97 171.92,116.44 172.11,116.63 172.53,116.63 172.84,116.94 172.84,118.16 172.76,118.24 171.72,118.24 170.9,119.06 170.9,119.39 170.06,120.23 170.06,120.95 170.09,120.98 170.09,121.72 169.87,121.94 168.01,121.94 167.59,121.52 167.59,120.83 167.41,120.66 167.22,120.66 166.93,120.95 165.9,120.95 165.53,120.58 163.26,120.58 163.17,120.67 163.17,121.18 163.58,121.59 163.58,125.08 164.72,126.22 164.72,130.73 163.84,131.61 151.08,131.61 144.82,137.86 144.82,146.01 144.83,146.01 144.83,152.16 145.24,152.57 164.07,152.57 164.22,152.42 175.83,152.42 176.59,151.66 176.59,149.98 177.71,148.86 179.72,148.86 180.03,149.18 180.03,149.98 180.37,150.32 180.37,151.22 180.66,151.5 181.78,151.5 182,151.28 189.69,151.28 190.77,150.2 190.77,145.49 191.17,145.1 191.17,138.57 193.55,136.19 193.55,134.89 193.56,134.88 193.56,134.52 196.75,131.34 196.75,130.24 193.62,127.12 193.62,121.61 193.22,121.2 182.67,121.2 178.29,116.82 174.66,116.82 174.29,117.19 174.02,117.19 173.62,116.8 173.62,114.34 173.41,114.13 ; 80 cut-outs
1D35V_VGA_S0 on BOTTOM: 168.86,55.57 168.48,55.95 168.48,61.54 168.73,61.79 184.22,61.79 184.73,61.28 184.73,58.11 183.33,56.71 177.87,56.71 177.24,57.35 175.59,57.35 175.46,57.22 175.46,55.69 175.33,55.57 ; 6 cut-outs
1D35V_VGA_S0 on BOTTOM: 180.38,144.6 179.17,145.81 179.09,145.81 178.61,145.33 178.23,145.33 178.08,145.48 178.08,145.79 178.53,146.25 178.53,147.27 179.66,148.4 179.66,149.74 179.3,150.1 179.3,151.12 179.42,151.25 180.91,151.25 181.1,151.06 183.66,151.06 183.77,151.17 187.09,151.17 188.11,152.19 188.97,152.19 189.1,152.06 189.1,148.23 188.8,147.93 184.83,147.93 184.1,147.19 184.1,146.32 183.99,146.21 182.78,146.21 181.17,144.6 ; 8 cut-outs
1D35V_VGA_S0 on BOTTOM: 146.78,145.41 146.43,145.77 146.43,147.77 146.04,148.16 146.04,150.19 146.73,150.89 152.4,150.89 152.49,150.98 152.99,150.98 153.07,150.9 153.07,150.24 154.67,148.64 154.67,147.5 154.3,147.13 154.3,146.83 154.48,146.65 154.48,146.32 154.4,146.24 153.95,146.24 153.62,146.58 153.3,146.58 152.87,146.14 152.87,145.57 152.71,145.41 150.92,145.41 150.82,145.51 150.82,145.86 150.54,146.14 149.98,146.14 149.68,145.84 149.68,145.64 149.45,145.41 ; 10 cut-outs
1D35V_VGA_S0 on BOTTOM: outline of 134 points within 159.51,134.56 181.89,151.21 ; 11 cut-outs
1D35V_VGA_S0 on BOTTOM: 194.28,128.21 193.98,128.52 193.98,134.15 194.82,134.99 196.52,134.99 196.52,131.87 196.72,131.67 196.72,128.87 196.06,128.21 ; 6 cut-outs
1D35V_VGA_S0 on BOTTOM: 173.05,114.17 172.92,114.29 172.92,120.01 172.41,120.52 163.52,120.52 162.89,121.15 162.89,121.53 163.01,121.66 163.78,121.66 163.9,121.53 166.16,121.53 166.37,121.33 167.03,121.33 167.23,121.53 169.36,121.53 170.13,122.29 170.4,122.29 170.52,122.17 170.52,121.97 170.25,121.7 170.25,121.37 170.46,121.16 170.81,121.16 171.18,121.53 172.79,121.53 172.92,121.41 174.57,121.41 174.7,121.28 174.7,120.9 174.06,120.26 173.94,120.26 173.94,116.33 174.7,115.56 174.7,115.21 173.65,114.17
1D35V_VGA_S0 on L3: outline of 87 points within 145.44,145.24 186.36,151.97
1D35V_VGA_S0 on L4: outline of 88 points within 145.44,145.24 186.36,151.97
1D35V_VGA_S0 on L4: 170.77,63.92 184.86,78.01 184.86,100.02 184.22,100.65 176.6,100.65 169.49,107.76 169.49,117.54 168.86,118.18 163.61,118.18 163.49,118.31 163.49,120.09 163.78,120.38 163.78,120.86 164.03,121.11 164.06,121.14 165.77,121.14 166.2,120.71 166.84,120.71 167.15,121.02 167.49,121.02 168.09,120.42 169.5,120.42 170.22,121.14 172.78,121.14 174.19,122.55 175.15,122.55 175.21,122.5 175.21,122.12 175.08,121.99 174.7,121.99 173.94,121.23 173.94,120.34 173.68,120.08 173.68,119.7 174.58,118.81 174.58,116.14 174.3,115.87 174.3,115.03 175.78,113.56 178.74,113.56 180.36,111.93 180.36,111.32 180.64,111.04 190.18,111.04 194.02,114.88 194.02,131.51 194.51,132 201.13,132 201.54,131.6 201.54,114.39 201.82,114.02 202.24,113.81 202.24,110 202.43,109.39 202.94,109 202.94,103.4 202.43,103.01 202.24,102.4 202.24,98.27 202.03,98.06 202.03,93.14 199.8,90.91 199.8,89.74 201.89,87.65 201.89,66.27 199.8,64.18 199.8,60.96 198.74,59.9 195.98,59.9 193.85,59.55 191.93,58.54 191.43,57.96 191.22,57.21 186.66,57.21 186.56,57.11 171.3,57.11 170.79,57.61 170.79,63.9
3D3V_AUX_KBC on TOP: 156.9,39.28 156.9,39.28 155.92,39.28 155.82,39.38 155.82,40.6 156.03,40.81 158.14,40.81 158.38,40.56 158.38,39.44 158.23,39.28
3D3V_CAMERA_S0 on TOP: 14.48,85.51 13.87,86.12 13.87,87.9 15.16,89.19 15.16,89.76 15.38,89.99 15.94,89.99 16.22,89.71 16.22,88.99 15.96,88.73 15.96,87.72 15.19,86.96 15.19,85.75 14.96,85.51
3D3V_CAMERA_S0 on BOTTOM: 29.97,82.08 29.23,82.82 27.02,82.82 26.99,82.86 26.12,82.86 25.74,83.24 24.6,83.24 23.8,84.04 23.8,84.45 24.13,84.78 25.6,84.78 26.49,83.89 27.25,83.89 27.29,83.93 27.42,83.93 27.46,83.89 29.69,83.89 30.45,83.13 31.52,83.13 31.77,82.87 31.77,82.36 31.49,82.08
3D3V_CAMERA_S0 on BOTTOM: 15.57,89.24 15.39,89.42 15.39,89.83 16.33,90.77 16.33,92.65 16.46,92.78 17.85,92.78 17.98,92.65 17.98,89.5 17.72,89.24 ; 4 cut-outs
3D3V_LAN_S5 on TOP: 38,53.52 37.92,53.61 37.92,54.5 38.12,54.7 38.12,56.52 37.26,57.38 37.26,58.26 36.37,59.14 35.52,59.14 35.44,59.23 35.44,60.4 35.62,60.58 35.92,60.58 36.16,60.34 36.16,60.33 36.78,60.33 36.88,60.44 37.74,60.44 37.95,60.64 37.95,60.98 38.02,61.05 38.43,61.05 39.12,60.36 39.12,58.8 38.61,58.28 38.61,57.57 39.34,56.84 42.57,56.84 43.36,57.62 44.17,57.62 45.21,56.59 48.84,56.59 49.64,57.39 49.64,62.23 45.47,66.4 45.47,67.45 45.64,67.63 47.32,67.63 51.81,63.14 51.81,57.35 48.52,54.06 43.27,54.06 42.73,53.52 ; 8 cut-outs
3D3V_LAN_S5 on TOP: 31.15,64.75 30.96,64.94 30.96,65.63 30.95,65.64 30.95,67.01 31.1,67.17 32.64,67.17 32.76,67.05 32.76,65.63 32.47,65.35 32.47,64.81 32.42,64.75
3D3V_LAN_S5 on BOTTOM: 35.75,58.64 35.65,58.73 35.65,59.37 35.02,60.01 33.56,60.01 30.74,62.83 30.74,65.24 31.16,65.66 32.32,65.66 32.48,65.5 32.48,63.12 33.9,61.7 34.89,61.7 36.21,60.38 37.46,60.38 37.58,60.27 37.58,60.1 36.97,59.5 36.97,59.46 36.97,59.46 36.97,58.77 36.84,58.64 ; 1 cut-out
3D3V_LAN_S5 on BOTTOM: 42.48,56.94 42.25,57.17 42.25,58.2 42.04,58.41 42.04,59.42 42.12,59.5 42.85,59.5 42.93,59.42 42.93,58.91 43.85,58 43.85,57.13 43.66,56.94 ; 1 cut-out
3D3V_LAN_S5 on BOTTOM: 43.3,66.88 43.13,67.05 43.13,67.82 43.28,67.98 46.04,67.98 46.21,67.81 46.21,67.08 46,66.88 ; 2 cut-outs
3D3V_PWR on BOTTOM: 120.47,10.36 120.34,10.48 120.34,13.66 120.72,14.04 120.72,21.02 121.61,21.91 127.96,21.91 128.47,21.4 128.47,10.61 128.38,10.52 120.9,10.52 120.74,10.36 ; 1 cut-out
3D3V_S0 on TOP: 17.46,72.69 16.86,73.29 16.86,74.02 17.17,74.33 17.17,75.01 17.07,75.12 16.49,75.12 16.41,75.2 16.41,75.61 16.51,75.71 17.5,75.71 18.62,74.59 18.62,72.98 18.33,72.69
3D3V_S0 on TOP: 39.44,71.43 39.44,72.15 39.83,72.54 47.81,72.54 48.06,72.8 48.06,73.52 48.27,73.73 51.01,73.73 51.05,73.68 51.05,71.7 50.8,71.44 50.8,70.53 50.73,70.46 49.01,70.46 48.34,71.12 39.75,71.12 ; 1 cut-out
3D3V_S0 on TOP: 125.79,57.22 125.75,57.26 125.75,58.32 125.31,58.76 125.31,60.21 125.41,60.32 126.56,60.32 126.82,60.05 126.82,58.59 126.67,58.43 126.35,58.43 126.19,58.28 126.19,57.27 126.14,57.22
3D3V_S0 on TOP: 179.63,8.55 179.52,8.65 179.52,9.49 179.65,9.62 181.02,9.62 181.2,9.44 182.73,9.44 182.73,8.91 182.67,8.86 181.3,8.86 181,8.55
3D3V_S0 on TOP: 37.47,62.5 37.04,62.93 37.04,64 37.04,64 37.04,64.48 37.09,64.53 37.89,64.53 37.94,64.47 37.94,63.96 38.45,63.46 38.45,62.58 38.37,62.5 ; 1 cut-out
3D3V_S0 on TOP: 148.13,118.89 148.05,118.97 148.05,119.45 148.08,119.47 148.43,119.47 148.54,119.58 149.31,119.58 149.43,119.71 149.43,120.14 149.46,120.17 150.22,120.17 150.25,120.14 150.25,119.18 149.97,118.89
3D3V_S0 on TOP: 115.44,110.99 114.55,111.88 113.84,111.88 113.74,111.98 113.74,113.23 113.92,113.4 114.86,113.4 115.39,112.87 117.5,112.87 117.65,112.72 117.65,112.26 116.89,111.5 116.89,111.09 116.79,110.99 ; 1 cut-out
3D3V_S0 on TOP: 127.8,3.88 127.79,3.89 126.55,3.89 126.25,4.18 126.25,5.85 126.59,6.19 130.94,6.19 131.02,6.11 131.02,5.38 130.43,4.8 130.43,4.11 130.2,3.88 ; 2 cut-outs
3D3V_S0 on TOP: 131.31,69.4 130.53,70.18 129.56,70.18 129.02,70.72 129.02,73.77 128.46,74.33 128.46,75.05 128.94,75.54 128.94,76.83 128.45,77.32 128.1,77.32 124.92,80.51 124.92,80.76 126.26,80.76 126.27,80.77 126.37,80.66 127.36,80.66 127.52,80.82 127.52,81.22 127.75,81.45 128.34,81.45 128.45,81.56 128.45,82.73 127.78,82.73 127.61,82.9 127.61,85.55 125.71,87.45 125.27,87.45 125.17,87.56 125.17,88.01 125.33,88.18 126.58,88.18 127.02,87.73 127.35,87.73 127.58,87.97 127.58,90.15 127.58,93.82 127.7,93.94 127.7,94.87 127.4,95.17 127.4,96.22 127.5,96.32 127.93,96.32 128.07,96.46 128.48,96.46 128.6,96.34 128.6,95.83 128.6,95.82 128.6,93.92 129.49,93.03 129.49,92.62 130.73,91.38 130.73,78.43 130.6,78.3 130.6,76.12 130.97,75.75 130.97,72.89 133.25,72.89 133.94,72.2 133.94,70.72 132.61,69.4 ; 3 cut-outs
3D3V_S0 on TOP: 124.43,54.22 124.2,54.45 124.2,54.91 124.38,55.08 125.6,55.08 125.75,55.22 125.75,56.31 125.8,56.36 126.15,56.36 126.24,56.27 126.24,54.39 126.07,54.22
3D3V_S0 on TOP: 180.16,23.84 179.42,24.58 178.74,24.58 178.53,24.78 176.91,24.78 176.86,24.83 176.86,24.99 176.88,25.01 179.27,25.01 179.42,25.16 180.06,25.16 180.31,24.91 184.15,24.91 184.29,24.78 184.29,23.91 184.22,23.85 183.54,23.85 183.31,24.07 182.82,24.07 182.6,23.85 181.73,23.85 181.73,23.84 ; 4 cut-outs
3D3V_S0 on TOP: 121.92,90.74 121.82,90.84 121.82,91.62 122.15,91.95 123.52,91.95 123.55,91.91 123.77,91.91 123.82,91.97 123.82,92.19 123.7,92.32 123.7,95.74 123.58,95.86 122.7,95.86 121.29,94.45 121.29,92.48 120.5,91.69 120.5,91.29 119.97,90.76 119.56,90.76 119.43,90.89 119.43,91.58 119.83,91.99 119.83,94.95 121.12,96.24 121.5,96.24 122.91,97.65 123.12,97.65 123.23,97.76 123.23,99.09 123.52,99.38 125.01,99.38 125.37,99.02 125.37,98.55 125.22,98.4 124.71,98.4 124.6,98.29 124.6,96.4 125.3,95.69 125.3,94.76 125.3,94.75 125.3,93.22 125.26,93.19 125.26,92.73 124.68,92.14 124.68,91.05 124.36,90.74 ; 2 cut-outs
3D3V_S0 on BOTTOM: 25.48,21.08 25.36,21.2 25.36,21.92 25.5,22.06 29.37,22.06 29.5,21.93 29.5,21.22 29.36,21.08 ; 1 cut-out
3D3V_S0 on BOTTOM: 125.68,97.35 125.17,97.86 124.28,97.86 123.26,98.87 123.26,99.13 123.39,99.26 123.9,99.26 124.66,98.49 126.82,98.49 127.07,98.24 127.07,97.6 126.82,97.35
3D3V_S0 on BOTTOM: 127.75,88.12 127.71,88.17 127.71,94.05 129.36,94.05 129.52,93.89 129.52,91.86 129.22,91.56 129.22,90.11 128.98,89.87 128.98,89.16 129.11,89.03 129.36,89.03 129.57,89.24 130.05,89.24 130.13,89.15 130.13,88.71 130.01,88.59 129.76,88.59 129.75,88.6 129.68,88.6 129.2,88.12
3D3V_S0 on BOTTOM: 177.39,39.74 177.31,39.82 177.31,41.42 178.41,42.52 181.72,42.52 181.84,42.39 181.84,41.94 181.77,41.87 179.72,41.87 179.38,41.53 179.38,40.03 179.09,39.74 ; 1 cut-out
3D3V_S0 on BOTTOM: 179.76,12.61 179.58,12.79 179.58,18.89 179.89,19.2 181.95,19.2 182.13,19.39 182.13,21.04 183.27,22.17 183.27,23.35 182.71,23.91 182.05,23.91 181.96,24 181.98,24.02 181.98,29.62 181.98,29.7 181.79,29.89 179.86,29.89 179.8,29.94 179.8,30.28 179.88,30.35 183.06,30.35 183.48,29.93 183.48,26.99 185.83,24.65 186.63,24.65 186.8,24.48 189.97,24.48 190.03,24.43 190.03,23.91 189.98,23.87 187.88,23.87 187.88,23.53 190.02,23.53 190.02,23.07 189.99,23.04 188.03,23.04 186.63,21.63 186.63,19.97 185.76,19.1 184.62,19.1 184.07,18.55 184.07,18.1 181.74,15.78 181.74,12.86 181.5,12.61 ; 2 cut-outs
3D3V_S0 on BOTTOM: 16.79,72.63 16.38,73.04 16.38,74.95 16.43,74.99 18.63,74.99 18.74,74.89 18.74,74.04 19,73.78 19.91,73.78 20.01,73.68 20.01,72.88 19.76,72.63 ; 2 cut-outs
3D3V_S0 on BOTTOM: 121.94,94.46 121.77,94.64 121.77,95.47 123.01,96.72 124.28,96.72 124.37,96.63 124.37,95.32 123.52,94.46 ; 2 cut-outs
3D3V_S0 on BOTTOM: 116.45,98.76 115.98,99.24 115.98,99.99 116.11,100.12 118.76,100.12 118.76,99.86 117.67,98.76
3D3V_S0 on BOTTOM: 18.39,91.73 18.22,91.9 18.22,93.54 18.32,93.64 20.96,93.64 21.27,93.33 21.27,92.16 20.84,91.73 ; 1 cut-out
3D3V_S0 on BOTTOM: 187.78,96.73 187.55,96.96 187.55,99.42 188.8,100.67 190.36,100.67 190.65,100.96 190.65,101.28 190.8,101.42 191.25,101.42 191.44,101.23 191.44,99.27 191.36,99.18 189.41,99.18 189.25,99.03 189.25,96.92 189.06,96.73 ; 5 cut-outs
3D3V_S0 on BOTTOM: 39.7,71.06 39.32,71.44 39.32,72.46 39.57,72.71 40.84,72.71 41.6,71.95 41.6,71.19 41.48,71.06 ; 1 cut-out
3D3V_S0 on L3: 129.72,6.29 142.09,6.29 142.7,5.68 142.7,4.13 143.07,3.75 146.07,3.75 146.09,3.77 147.56,3.77 149.33,5.54 153.46,5.54 156.82,8.9 156.82,12.64 160.51,16.33 164.13,16.33 164.85,17.06 180.14,17.06 180.78,16.41 180.78,13.08 180.44,12.74 162.46,12.74 159.27,9.54 159.27,6.07 154.77,1.58 128.41,1.58 128.18,1.34 77.36,1.34 76.88,1.82 76.88,3.49 72.01,8.36 69.6,8.36 67.9,6.66 55.47,6.66 41.5,20.63 37.3,20.63 36.82,21.11 26.21,21.11 25.64,21.68 25.64,25.29 27.67,27.33 35.1,27.33 36.17,26.25 43.11,26.25 49.93,19.42 49.93,18.69 57.99,10.63 65.92,10.63 66.79,11.5 73.73,11.5 80.8,4.44 125.5,4.44 128.19,7.13 128.88,7.13
3D3V_S0 on L3: 182.39,43.78 183.67,45.06 183.67,45.71 184.5,46.55 186.45,46.55 187.95,48.05 187.95,53.32 187.95,53.32 187.95,60.46 191.53,64.04 191.53,83.94 190.68,84.79 190.68,95.3 188.26,97.71 187.8,97.71 187.41,97.32 187.41,96.89 188.91,95.39 188.91,63.8 185.97,60.86 185.97,50.76 182.15,46.93 182.15,46.92 181.83,46.61 181.83,45.55 177.85,41.56 177.85,40.04 177.97,39.91 179.61,39.91 182.39,42.69
3D3V_S0 on L3: 134.38,93.99 134.82,93.99 135.21,94.37 143.13,94.37 143.96,95.21 150.19,95.21 150.31,95.08 150.31,93.92 150.05,93.65 144.84,93.65 143.11,91.91 134.6,91.91 134.21,91.53 133.04,91.53 132.51,91 131.65,91 131.11,91.53 130.13,92.51 128.85,92.51 128.22,93.15 128.22,94.07 128.47,94.33 130.24,94.33 131.68,92.89 133.28,92.89
3D3V_S0 on L3: 37.43,62.44 37.23,62.64 37.23,63.57 34.95,65.84 34.95,70.45 37.41,72.92 39.47,72.92 42.21,75.66 42.21,82.49 40.97,83.74 38.15,83.74 37.82,84.07 37.82,86.2 38.12,86.5 41.25,86.5 45.41,82.34 45.41,78.55 46.3,77.67 46.3,74.87 44.42,72.99 43.74,72.99 41.09,70.34 41.09,70.02 40.33,69.26 40.01,69.26 39.66,68.91 38.52,68.91 38.25,68.64 38.25,68.01 38.35,67.91 38.35,67.91 39.36,66.9 39.36,62.79 39.01,62.44
3D3V_S0 on L3: 126.02,54.25 126.26,54.49 126.26,56.12 127,56.87 127,60.4 124.57,62.83 123.66,62.83 122.63,63.86 122.63,66.44 122.88,66.7 125.64,66.7 127.95,69.01 127.95,70.54 129.87,72.46 129.87,75.41 129.11,76.17 123.28,76.17 121.16,74.05 121.16,69.07 119.97,67.89 119.97,62.36 122.64,59.69 122.65,59.69 123.73,58.61 123.73,54.43 123.91,54.25
3D3V_S0 on L4: 26.21,21.3 26.08,21.43 26.08,38.09 31.18,43.18 31.18,43.77 33.52,46.11 33.52,47.4 36.9,50.78 36.9,59.17 36.52,59.55 36.52,60.55 36.9,60.93 36.9,63.26 37.64,64 39.24,64 39.8,63.44 39.8,63.44 41.56,63.44 42.65,62.35 42.65,57.7 40.4,55.45 40.4,52.42 39.8,51.83 39.8,49.19 39.76,49.15 39.76,48.75 33.31,42.3 33.31,41.09 29.53,37.31 29.53,30.33 29.53,30.33 29.53,21.52 29.31,21.3
3D3V_S0 on L4: 40.78,71.53 40.78,72.94 40.64,73.09 38.33,73.09 38.19,72.95 38.19,71.38 38.3,71.27 40.51,71.27
3D3V_S0 on L4: 147.27,119.6 149.63,119.6 149.91,119.32 149.91,118.66 149.6,118.36 147.8,118.36 147.04,117.59 147.04,111.37 149.65,108.75 149.65,104.77 149.02,104.13 149.02,101.69 149.55,101.16 149.55,97.1 150.82,95.83 150.82,94.56 150.44,94.18 149.81,94.18 149.58,94.4 149.58,94.84 147.7,96.72 147.7,104.77 148.26,105.33 148.26,108.3 145.72,110.84 145.72,118.05
3D3V_S0 on L4: 112.75,12.64 113.71,12.64 113.87,12.79 113.87,21.79 114.3,22.22 114.3,30.14 116.13,31.97 116.13,37.51 116.15,37.53 116.15,38.42 120.57,42.84 120.57,49.88 123.49,52.8 125.17,52.8 126.26,53.89 126.26,54.96 126.16,55.06 123.95,55.06 119,50.11 119,43.68 114.62,39.31 114.62,33.85 114.14,33.37 112.5,33.37 112.01,32.88 112.01,28.85 113.1,27.75 113.1,22.85 112.11,21.86 112.11,15.66 112.49,15.28 112.49,12.9
3D3V_S0 on L4: 180.62,23.36 180.61,23.35 180.61,22.26 178.92,20.57 178.92,20.49 177.88,19.45 177.88,17.6 178.92,16.57 178.92,11.48 177.96,10.52 177.96,9.32 179.13,8.15 180.22,8.15 182.12,10.05 182.12,20.59 183.23,21.7 183.23,31.1 182.12,32.22 182.12,35.17 182.11,35.17 182.11,40.14 180.86,41.39 178.5,41.39 178.36,41.26 178.36,39.85 179.09,39.12 179.09,30.76 180.62,29.24
3D3V_S0 on L4: 40.63,88.91 37.05,92.5 24.46,92.5 22.86,94.1 12.6,94.1 10.59,92.09 10.59,86.38 10.26,86.05 10.26,79.06 11.5,77.81 12.69,77.81 13.18,77.33 13.18,76.04 13.65,75.57 14.62,75.57 17.52,72.66 18.65,72.66 19.27,73.29 19.27,77.16 18.38,78.05 16.41,78.05 13.84,80.61 13.84,89.52 15.81,91.48 20.97,91.48 22.45,90.01 34.63,90.01 37.51,87.13 37.51,84.68 37.77,84.42 38.12,84.42 40.63,86.93
3D3V_S5 on TOP: 109.59,142.21 109.35,142.46 109.35,143.03 109.95,143.64 110.51,144.19 110.75,144.19 110.94,144.39 110.94,145.08 110.45,145.57 110.45,147.07 110.77,147.39 111.25,147.39 111.34,147.3 111.34,146.07 111.73,145.68 111.73,144.37 111.44,144.07 111.44,142.79 110.86,142.21
3D3V_S5 on TOP: 122.2,6.47 121.87,6.8 121.87,10.23 122.35,10.71 130.5,10.71 130.68,10.53 130.68,8.7 130.99,8.39 130.99,7.58 130.91,7.5 130.36,7.5 129.32,6.47
3D3V_S5 on TOP: 122.5,85.29 122.37,85.41 122.37,85.56 122.88,86.07 122.88,86.43 123.26,86.81 124.03,86.81 124.28,86.56 124.28,85.67 124.15,85.54 123.14,85.54 122.88,85.29
3D3V_S5 on TOP: 40.71,42.66 39.93,43.45 39.93,48.56 38.96,49.52 37.36,49.52 37.23,49.65 37.23,50.49 38.35,51.6 38.35,52.37 38.75,52.76 40.21,52.76 42.85,50.12 42.85,43.12 42.39,42.66 ; 2 cut-outs
3D3V_S5 on TOP: 142.32,11.27 142.26,11.32 142.26,12.62 142.33,12.68 145.69,12.68 145.85,12.52 145.85,11.42 145.69,11.27
3D3V_S5 on BOTTOM: 151.43,33.99 151.38,34.04 151.38,36.34 152.26,36.34 152.97,37.05 152.97,40.16 151.86,41.27 151.86,42.98 152.04,43.17 154.17,43.17 154.33,43.01 154.33,41.51 153.89,41.07 153.89,38.2 154.24,37.85 154.26,37.86 155.35,37.86 155.35,37.84 155.61,37.58 155.61,36.9 155.42,36.71 154.68,36.71 154.66,36.72 153.48,36.72 153.04,36.29 153.04,35.38 152.71,35.04 152.25,35.04 152.09,34.88 152.09,34.03 152.06,34 151.91,34 151.9,33.99 ; 2 cut-outs
3D3V_S5 on BOTTOM: 140.03,83.76 139.77,84.02 139.77,85.03 141.42,86.68 141.42,95.83 141.04,96.21 140.41,96.21 140.28,96.33 140.28,98.49 139.27,99.51 139.27,106.11 136.73,108.65 136.73,111.07 136.85,111.19 137.49,111.19 137.74,110.94 137.74,109.42 140.41,106.75 140.41,100.02 142.95,97.48 142.95,86.05 140.66,83.76 ; 1 cut-out
3D3V_S5 on BOTTOM: 130.08,48.83 129.96,48.96 129.96,49.77 130.04,49.85 132.39,49.85 132.68,50.14 132.68,54.86 135.33,57.51 135.33,60.83 135.48,60.98 136.31,60.98 136.47,60.81 136.47,58.62 136.6,58.49 137.36,58.49 137.61,58.74 137.61,59.31 138.11,59.8 140.85,59.8 141.22,59.43 141.22,58.03 140.46,57.27 137.13,57.27 134.1,54.24 134.1,49.59 133.35,48.83 ; 2 cut-outs
3D3V_S5 on BOTTOM: 121.89,8.56 121.64,8.81 121.64,10.06 121.77,10.18 126.03,10.18 126.18,10.02 126.18,8.78 125.97,8.56
3D3V_S5 on BOTTOM: 134.27,83.37 134.19,83.46 134.19,83.55 133.64,84.09 133.64,85.9 133.14,86.4 133.14,87.73 132.92,87.95 132.92,88.91 132.44,89.38 132.44,90.01 132.53,90.1 132.53,90.89 132.78,91.13 132.79,91.13 133.3,91.13 133.68,90.75 133.68,89.48 133.93,89.22 134.12,89.22 135.14,88.21 135.14,84.3 134.95,84.11 134.95,83.45 134.87,83.37 ; 2 cut-outs
3D3V_S5 on L3: 144.03,12.82 145.76,12.82 145.85,12.72 145.85,11.33 145.7,11.17 144.11,11.17 143.94,11.34 143.94,12.72
3D3V_S5 on L3: 125.15,4.9 126.16,5.91 126.16,9.39 126.05,9.5 122.03,9.5 119.96,7.43 81.7,7.43 79.04,10.09 79.04,10.76 74.34,15.46 60.19,15.46 59.18,16.47 59.18,19.2 58.88,19.5 55.28,19.5 54.97,19.18 54.97,14.79 57.83,11.93 57.86,11.9 73.53,11.9 80.54,4.9
3D3V_S5 on L3: 114.32,83.37 117.29,83.37 117.44,83.22 117.44,82.41 117.24,82.21 114.84,82.21 114.59,82.46 114.42,82.46 114.17,82.71 114.17,83.31 114.23,83.37
3D3V_S5 on L4: 42.62,43.78 41.48,43.78 40.89,43.2 40.89,40.23 40.99,40.12 42.77,40.12 42.97,40.33 42.97,43.43
3D3V_S5 on L4: 55.95,20.13 55.96,20.13 56.6,20.13 56.75,19.97 56.75,17.98 56.49,17.72 52.52,17.72 49.98,20.26 49.98,20.9 50.87,21.79 51.51,21.79 53.16,20.13
3D3V_S5_PCH on BOTTOM: 128.01,83.24 127.93,83.32 127.93,84.36 127.63,84.66 127.63,86.09 127.67,86.14 128.23,86.14 128.34,86.03 128.34,85.33 128.49,85.17 128.88,85.17 129.07,84.98 129.07,83.36 128.95,83.24 ; 1 cut-out
3D3V_S5_PCH on BOTTOM: 138.17,60.47 137.93,60.71 137.93,61.25 137.95,61.26 137.95,62.15 137.35,62.75 135.45,62.75 135.34,62.86 135.34,64.58 134.78,65.14 134.78,66 132.64,68.14 132.64,70.17 132.94,70.48 132.94,73.12 132.8,73.26 132.8,75.71 132.92,75.82 132.92,82.27 133.08,82.43 133.79,82.43 134.5,83.15 134.88,83.15 135.05,83.32 135.05,84.09 135.24,84.28 135.24,88.1 133.77,89.57 133.77,89.94 133.98,90.15 134.69,90.15 134.72,90.13 134.93,90.13 136.24,88.82 136.24,88.61 136.28,88.57 136.28,88.39 136.68,87.98 136.68,83.63 135.87,82.83 135.87,81.83 134.44,80.4 134.44,73.5 135.07,72.86 135.07,71.57 135.05,71.54 135.05,68.93 139.71,64.26 139.71,60.68 139.51,60.47 ; 2 cut-outs
3D3V_VGA_OUT1 on TOP: 151.77,118.28 151.71,118.34 151.71,119.48 151.64,119.55 151.64,120.16 151.65,120.17 152.48,120.17 152.71,119.94 152.71,119.47 153.34,118.85 153.34,118.36 153.26,118.28
3D3V_VGA_S0 on TOP: 179.07,101.38 178.88,101.56 178.88,102.63 179.29,103.04 183.25,103.04 188.23,108.02 189.02,108.02 189.41,108.4 189.41,112.34 188.11,113.63 188.11,116.58 188.29,116.76 189.61,116.76 189.84,116.53 189.84,113.86 191.67,112.03 191.67,105.56 191.36,105.25 190.78,105.25 190.78,105.33 189.9,106.21 188.9,106.21 184.08,101.39 183.7,101.39 183.69,101.38
3D3V_VGA_S0 on TOP: 172.96,109.94 172.92,109.98 172.92,112.57 172.96,112.61 173.5,112.61 173.86,112.25 174.21,112.25 174.44,112.02 174.44,110.37 174.35,110.28 173.79,110.28 173.45,109.94 ; 3 cut-outs
3D3V_VGA_S0 on BOTTOM: 178.64,100.68 178.55,100.76 178.55,102.48 178.67,102.59 180.09,102.59 180.4,102.28 180.4,100.9 180.22,100.71 180.21,100.71 180.18,100.68
3D3V_VGA_S0 on BOTTOM: 190.85,102.18 190.6,102.42 190.6,106 190.84,106.23 192.21,106.23 192.43,106.01 192.43,102.33 192.28,102.18 ; 3 cut-outs
3D3V_VGA_S0 on BOTTOM: 187.4,116.22 187.25,116.37 187.25,116.78 187.4,116.93 189.23,116.93 189.35,117.06 189.35,117.84 189.18,118.02 187.04,118.02 187.01,118.05 187.01,118.52 187.09,118.61 187.52,118.61 187.73,118.82 188.39,118.82 188.39,118.81 188.44,118.81 188.57,118.94 188.57,119.47 188.62,119.52 189.22,119.52 189.99,118.75 189.99,116.58 189.63,116.22 ; 3 cut-outs
3D3V_VGA_S0 on L3: 173.05,111.47 173.71,111.47 174.67,110.51 175.18,110.51 176.47,109.22 176.47,108.39 181.21,103.65 181.21,102.33 180.67,101.8 179.27,101.8 178.54,102.53 178.48,102.53 172.69,108.31 172.69,111.11
+0D675V_DDR_P on TOP: 107.52,11.9 106.37,13.05 106.37,13.78 107.13,13.78 107.13,13.53 107.01,13.4 107.01,13.15 107.26,12.9 107.52,12.9 108.4,13.78 108.4,14.29 108.28,14.42 106.37,14.42 106.37,14.67 107.64,14.67 108.28,15.31 108.28,17.59 108.53,17.85 109.93,17.85 110.06,17.72 110.06,12.39 109.57,11.9 ; 10 cut-outs
+1.05M_ASW on TOP: 113.95,78.97 112.85,80.07 112.85,80.37 112.68,80.54 110.88,80.54 110.6,80.25 107.26,80.25 107.14,80.37 107.14,80.94 107.3,81.09 109.44,81.09 110.01,81.66 112.95,81.66 112.96,81.65 113.71,81.65 114.15,81.22 114.15,80.47 114.88,79.73 114.88,79.11 114.74,78.97
+1.05M_ASW on TOP: 103.01,79.96 102.87,80.1 102.87,82.08 102.92,82.13 103.81,82.13 103.87,82.07 103.87,81.51 104.59,80.78 104.59,80.08 104.47,79.96
+1.05M_ASW on L3: 112.9,80.51 113.18,80.51 113.33,80.36 113.33,80.09 113.94,79.48 113.94,78.29 113.66,78.01 113.66,74.15 112.88,73.37 109.27,73.37 108.66,73.98 108.66,74.52 107.67,75.51 104.38,75.51 102.86,77.02 102.86,81.14 103.33,81.62 104.42,81.62 104.99,81.05 106.05,81.05 107.68,79.42 110.84,79.42 111.24,79.82 112.3,79.82 112.36,79.88 112.55,79.88 112.81,80.14 112.81,80.42
+DC_IN on BOTTOM: 97.43,146.19 97.34,146.28 97.34,148.37 97.28,148.43 94.92,148.43 94.43,148.91 94.43,150.69 93.16,151.96 91.18,151.96 91.03,152.11 91.03,155.41 91.34,155.72 102.56,155.72 102.89,155.39 102.89,153.1 102.82,153.03 100.78,153.03 100.62,153.19 100.62,153.6 100.2,154.02 98.27,154.02 97.81,153.56 97.81,150.84 98.31,150.35 100.12,150.35 100.54,149.93 103.32,149.93 103.53,149.72 103.53,147.47 103.53,147.46 103.53,147.31 103.48,147.26 98.88,147.26 98.58,146.96 98.58,146.35 98.42,146.19 ; 2 cut-outs
+DC_IN_C on TOP: 101.09,143.2 100.86,143.42 100.86,148.05 101.08,148.27 105.62,148.27 105.88,148.02 105.88,147.04 106.18,146.73 106.52,146.73 106.78,146.47 106.78,144.25 106.23,143.71 103.65,143.71 103.44,143.5 103.44,143.26 103.37,143.2
+DC_IN_C on BOTTOM: 99.11,143.34 98.82,143.62 98.82,146.62 99.01,146.8 101.24,146.8 101.5,147.06 103.68,147.06 104.21,147.59 105.03,147.59 105.8,148.36 106.29,148.36 106.68,147.97 106.68,145.03 106.5,144.85 105.1,144.85 104.34,144.09 103.67,144.09 102.92,143.34 ; 2 cut-outs
+PWR_SRC_1D35V on TOP: 92.66,11.5 92.4,11.75 92.4,15.18 92.53,15.31 99.01,15.31 99.13,15.18 99.13,11.63 99.01,11.5 ; 2 cut-outs
+PWR_SRC_1D35V on BOTTOM: 95.86,11.88 95.56,12.17 95.56,15.33 95.67,15.44 100.91,15.44 101.04,15.31 101.04,12.26 100.66,11.88
AD+ on BOTTOM: 87.25,144.72 87.09,144.89 87.09,147.69 87.45,148.06 87.45,149.93 87.25,150.13 86.79,150.13 86.61,150.31 86.61,154.09 86.89,154.37 90.55,154.37 90.7,154.22 90.7,151.22 91.51,150.41 91.51,144.85 91.39,144.72 ; 3 cut-outs
AD+ on BOTTOM: 109.41,132.6 109.27,132.74 109.27,134.43 109.29,134.46 110.79,134.46 110.84,134.41 110.84,132.78 110.66,132.6 ; 1 cut-out
AD+_TO_SYS on BOTTOM: 86.23,140.83 86.15,140.91 86.15,141.9 87.32,143.07 88.21,143.07 88.34,143.2 88.34,144.34 88.47,144.47 91.77,144.47 91.92,144.31 91.92,143.81 91.82,143.71 91.39,143.71 91.26,143.58 91.26,141.17 91.13,141.04 87.32,141.04 87.12,140.83
AD_OFF_R on BOTTOM: 94.59,146.19 94.43,146.35 94.43,147.26 93.16,148.53 93.16,150.06 92,151.22 91.18,151.22 91.03,151.38 91.03,151.78 91.08,151.83 92.78,151.83 94.18,150.44 94.18,148.91 94.79,148.3 96.9,148.3 97.03,148.18 97.03,146.4 96.82,146.19 ; 1 cut-out
AUD_AGND on TOP: 36.43,17.19 36.32,17.3 36.32,18.3 35.9,18.72 34.3,18.72 33.93,18.36 33.22,18.36 33.09,18.36 32.99,18.46 32.99,18.89 32.82,19.06 31.67,19.06 31.32,19.41 31.32,20.65 31.44,20.78 36.48,20.78 37.01,20.25 37.01,17.28 36.92,17.19 ; 7 cut-outs
AUD_AGND on TOP: 16.33,5.48 16.08,5.73 16.08,6.73 16.36,7.01 18.74,7.01 19,6.75 19,5.7 18.78,5.48 ; 2 cut-outs
AUD_AGND on BOTTOM: 25.06,5.57 24.92,5.71 24.92,6.44 25.05,6.57 27.16,8.68 27.16,9.58 26.53,10.2 26.53,10.65 26.78,10.91 28.99,10.91 29.18,10.71 29.18,9.1 29.02,8.94 28.45,8.94 28.14,8.63 28.14,6.14 27.58,5.57 ; 1 cut-out
AUD_AGND on L2VCC, L5GND: 2.2,0.51 1.85,0.65 1.71,1 1.71,3.64 12.8,3.64 13.77,4.39 13.31,5.52 13.31,10.58 13.77,11.71 12.8,12.46 1.71,12.46 1.71,13.61 2.32,13.61 2.32,14.58 2.34,14.71 2.38,14.83 2.77,15.5 13.71,15.5 17.52,11.69 22.38,11.69 24.9,14.21 24.9,19.42 26.19,20.71 36.57,20.71 36.84,20.44 36.84,18.4 37.98,17.26 37.98,13.48 37.84,13.34 33.65,13.34 33.16,12.85 33.16,9.67 33.14,9.66 31.36,9.66 30.86,9.15 28.44,9.15 27.82,8.53 27.82,5.7 28.44,5.08 31.01,5.08 32.69,6.76 33.28,6.76 33.79,7.27 33.79,8.24 33.81,8.26 34.67,8.26 34.68,8.24 34.68,7.05 33.92,6.29 33.92,2.79 33.65,2.51 33.32,2.51 33.25,2.58 33.25,2.72 32.87,3.1 32.87,3.83 32.63,4.07 31.04,4.07 30.73,3.76 30.73,3.12 30.67,3.05 27.81,3.05 27.32,2.56 27.32,0.51
BAT_ALERT on TOP: 127.4,151.05 127.28,151.17 127.28,151.4 128.7,152.82 128.7,155.69 128.93,155.92 129.49,155.92 129.74,155.67 129.74,153.1 127.68,151.05
BT+ on TOP: 136.47,144.72 136.22,144.98 136.22,149.55 135.71,150.06 135.71,152.21 138.07,154.58 138.07,155.92 138.63,156.48 141.73,156.48 142.82,155.39 142.82,152.7 142.29,152.16 142.29,146.52 142.03,146.27 141.32,146.27 140.66,146.93 140.1,146.93 139.82,146.65 139.82,144.81 139.73,144.72 ; 2 cut-outs
BT+ on BOTTOM: 133.93,141.55 133.83,141.65 133.83,142.89 133.66,143.07 132.7,143.07 132.6,143.17 132.6,147.03 132.7,147.13 135.46,147.13 136.22,147.9 136.22,152.72 138.38,154.88 138.38,156.66 138.5,156.79 142.69,156.79 142.82,156.66 142.82,151.33 142.53,151.04 142.53,141.92 142.16,141.55 ; 6 cut-outs
BT+_R on BOTTOM: 126.11,137.51 125.88,137.74 125.88,143.6 126.82,144.54 126.82,146.82 126.98,146.98 131.94,146.98 132.05,146.87 132.05,143.24 131.91,143.1 130.97,143.1 130.88,143.02 130.88,142.21 131.11,141.98 131.11,137.86 130.76,137.51
CHARGER_SRC on TOP: 111.33,136.09 111.07,136.34 111.07,137.99 111.33,138.24 115.64,138.24 115.9,137.99 115.9,136.47 115.52,136.09 ; 2 cut-outs
CHARGER_SRC on BOTTOM: 115.64,134.69 115.26,135.07 111.71,135.07 111.33,135.45 111.33,137.74 111.58,137.99 113.23,137.99 113.48,138.24 118.82,138.24 119.07,137.99 119.07,134.82 118.95,134.69 ; 4 cut-outs
CHG_AGND on TOP: 102.93,133.14 102.8,133.27 102.8,135.32 103.07,135.59 103.07,141.44 103.35,141.72 104.67,141.72 104.77,141.62 104.77,141.19 104.29,140.71 104.29,139.31 104.34,139.26 105.36,139.26 105.74,138.88 105.74,136.72 105.61,136.59 103.83,136.59 103.71,136.47 103.71,133.22 103.63,133.14 ; 5 cut-outs
CHG_AGND on L3: 98.25,138.98 98.25,139.27 98.65,139.67 103.86,139.67 104.59,138.93 105.91,138.93 106,138.84 106,137.12 107.74,135.38 107.74,134.9 107.61,134.77 106.94,134.77 106.2,135.51 103.62,135.51 103.42,135.31 103.42,134.79 103.26,134.63 102.72,134.63 102.61,134.74 102.61,136.72 100.76,138.57 98.65,138.57
DCBATOUT on TOP: 85.71,129.74 85.52,129.93 85.52,133.79 85.92,134.19 91,134.19 91.2,133.98 91.2,130.11 90.83,129.74 ; 2 cut-outs
DCBATOUT on TOP: outline of 127 points within 95.72,2.86 156.03,136.77 ; 37 cut-outs
DCBATOUT on TOP: 54.35,86.75 54.3,86.81 54.3,88.47 54.6,88.77 54.97,88.77 55.25,89.05 55.25,89.33 55.67,89.75 55.67,95.85 56.11,96.28 59.34,96.28 59.44,96.18 59.44,95.49 59.23,95.27 57.48,95.27 57.32,95.11 57.32,88.79 57.83,88.29 57.83,86.79 57.79,86.75 ; 3 cut-outs
DCBATOUT on BOTTOM: 151.33,57.22 150.95,57.6 150.95,60.88 151.16,61.09 152.52,61.09 152.61,61.01 152.61,59.97 152.6,59.96 152.6,57.22 ; 1 cut-out
DCBATOUT on BOTTOM: 99.92,124.66 97.99,126.59 93.8,126.59 93.27,126.05 85.93,126.05 85.42,126.56 85.42,140.28 85.67,140.53 91.26,140.53 91.39,140.4 91.39,132.02 92.05,131.36 99.08,131.36 100.02,130.42 103.53,130.42 104.21,129.74 111.75,129.74 112.04,130.02 112.04,132.03 112.6,132.59 112.6,133.16 111.96,133.8 111.96,134.69 112.09,134.82 115.01,134.82 115.7,134.12 122.85,134.12 125.5,136.77 131.17,136.77 132.3,137.91 132.3,138.27 133.8,139.77 137.32,139.77 137.57,140.01 137.57,141.27 137.61,141.32 141.17,141.32 141.4,141.09 141.4,136.42 135.13,130.14 133.09,130.14 132,129.05 127.96,129.05 126.28,127.37 125.02,127.37 123.94,126.29 121.83,126.29 120.2,124.66 ; 8 cut-outs
DCBATOUT on L4: 99.92,124.66 97.99,126.59 93.8,126.59 93.27,126.05 87.4,126.05 86.76,126.69 86.76,133.32 87.25,133.8 91.26,133.8 91.39,133.67 91.39,132.61 91.92,132.07 98.85,132.07 100.05,130.88 105,130.88 105.33,130.55 108.43,130.55 108.99,129.99 112.34,129.99 114.85,132.5 119.54,132.5 120.04,132 120.04,125.75 118.95,124.66
DCBATOUT_LCD on TOP: 51.12,81.07 50.55,81.64 49.93,81.64 49.92,81.64 47.67,81.64 46.29,83.02 46.29,84.46 46.59,84.77 54.29,84.77 54.29,84.77 57.96,84.77 58.16,84.58 58.16,82.33 56.9,81.07 ; 4 cut-outs
DDR_VREF_S3 on TOP: 106.37,19.75 106.25,19.88 106.25,21.4 106.37,21.53 107.26,21.53 107.39,21.4 107.39,19.88 107.26,19.75
DDR_VREF_S3 on TOP: 57.97,33.07 57.84,33.2 57.84,33.97 57.95,34.08 58.23,34.08 58.73,34.58 58.73,35.24 58.89,35.4 58.89,36.89 58.95,36.94 59.51,36.94 59.57,36.89 59.57,35.43 59.76,35.23 59.76,34.15 58.69,33.07
FBA_PLL_AVDD on TOP: 164.74,119.09 164.59,119.25 163.65,119.25 163.52,119.37 163.52,120.26 163.65,120.39 165.81,120.39 165.93,120.52 165.93,120.69 166.06,120.82 166.95,120.82 166.95,120.52 167.08,120.39 167.46,120.39 167.59,120.26 167.59,119.5 167.33,119.25 166.06,119.25 165.91,119.09
FBA_PLL_AVDD on L3: 168.86,120.39 168.73,120.52 168.73,121.79 168.47,122.04 168.09,122.04 167.84,121.79 167.84,120.52 167.71,120.39 167.33,120.39 167.08,120.14 167.08,119.75 167.2,119.63 170.89,119.63 173.68,116.83 173.68,116.45 173.81,116.33 174.44,116.33 174.57,116.45 174.57,116.96 172.79,118.74 172.79,119.25 173.81,120.26 173.81,121.91 173.68,122.04 173.05,122.04 172.92,121.91 172.92,120.52 172.79,120.39
GPU_PLL_VDD on TOP: 171.13,105.83 171.07,105.88 171.07,107.76 170.51,108.32 170.51,109.03 170.66,109.19 171.75,109.19 172.16,108.78 172.16,105.95 172.04,105.83 ; 3 cut-outs
HSIO_OUT on BOTTOM: 122.5,102.75 122.25,103 122.25,105.03 122.76,105.54 125.17,105.54 125.3,105.42 125.3,104.15 125.04,103.89 124.53,103.89 124.46,103.81 124.46,102.95 124.25,102.75
JGND on TOP: 105.23,149.73 105.13,149.83 104.27,149.83 103.89,150.2 103.89,151.02 103.65,151.26 101.15,151.26 101.06,151.35 101.06,156.11 101.13,156.18 103.4,156.18 103.93,155.64 105.66,155.64 106.14,155.16 106.14,153.71 105.74,153.31 105.74,152.44 105.99,152.19 106.91,152.19 107.15,151.94 107.15,149.94 106.95,149.73
JGND on BOTTOM: 103.95,148.28 103.91,148.32 103.91,152.08 104.08,152.25 105.73,152.25 105.73,152.24 106.86,152.24 107.17,151.93 107.17,149.95 106.49,149.27 106.49,148.78 106.39,148.68 105.83,148.68 105.42,148.28 ; 1 cut-out
LCDVDD on TOP: 47.62,74.41 47.08,74.95 47.08,77.44 47.21,77.56 49.15,77.56 49.25,77.46 49.25,76.37 49.12,76.24 49.12,74.54 48.99,74.41
LCDVDD_LCD on TOP: 47.11,77.92 46.95,78.07 46.95,79.58 43.79,82.74 43.79,83.94 43.81,83.96 44.1,83.96 44.1,83.02 44.3,83.02 44.3,83.96 44.6,83.96 44.6,83.03 44.8,83.03 44.8,83.96 45.1,83.96 45.1,83.03 45.3,83.03 45.3,83.96 45.56,83.96 45.62,83.9 45.62,82.97 45.8,82.8 46.28,82.8 47.8,81.27 49.05,81.27 49.43,80.89 49.43,79.39 49.35,79.32 49.35,77.97 49.3,77.92 ; 3 cut-outs
M_VREF_CA_DIMMA on TOP: 63.83,48.99 63.7,49.12 63.7,50.11 63.88,50.28 65.68,50.28 65.86,50.46 65.86,52.57 65.96,52.67 67.36,52.67 67.49,52.54 67.49,50.77 67.47,50.75 67.47,50.07 66.39,48.99 ; 4 cut-outs
M_VREF_CA_DIMMA on TOP: 60.2,34.74 60.13,34.81 60.13,35.74 59.76,36.1 59.76,37.78 59.94,37.95 61.25,37.95 61.41,37.79 61.41,34.92 61.24,34.74 ; 2 cut-outs
M_VREF_CA_DIMMA on TOP: 90.24,21.53 89.86,21.91 89.86,23.04 89.79,23.11 89.79,24.59 89.96,24.76 90.46,24.76 90.6,24.62 90.6,23.96 90.75,23.81 90.75,21.65 90.62,21.53 ; 2 cut-outs
M_VREF_DQ_DIMMA on TOP: 49.32,28.9 49.17,29.06 49.17,31.98 49.43,32.24 49.43,35.07 52.02,37.66 57.48,37.66 57.94,38.12 58.52,38.12 58.6,38.04 58.6,35.53 58.54,35.48 52.27,35.48 50.68,33.89 50.68,32.17 49.98,31.46 49.98,29.03 49.85,28.9 ; 7 cut-outs
M_VREF_DQ_DIMMA on BOTTOM: 49.48,28.87 49.25,29.1 49.25,30.78 50.19,31.72 50.37,31.72 50.4,31.68 50.4,29.32 49.96,28.87
MCT on TOP: 21.54,45.61 21.41,45.74 21.41,46.88 21.54,47.01 24.08,47.01 24.2,47.13 24.2,47.87 24.28,47.95 25.52,47.95 25.6,47.87 25.6,45.61
ODD_PWR_5V on TOP: 196.61,71.83 196.52,71.92 196.52,73.75 197.45,74.68 197.45,79.04 198.37,79.96 198.37,83.41 198.37,83.41 198.37,83.75 198.54,83.91 200.12,83.91 200.38,83.66 201.01,83.66 201.56,84.2 202.41,84.2 202.83,83.78 202.83,82.87 202.2,82.25 201.64,82.25 201.31,81.92 201.31,77.4 200.48,76.57 200.48,73.4 198.93,71.84 198.43,71.84 198.42,71.83
ODD_PWR_5V on BOTTOM: 193.88,79.44 193.62,79.7 193.62,84.78 193.75,84.9 198.96,84.9 200.23,83.63 201.11,83.63 202,84.52 202.51,84.52 202.77,84.27 202.77,82.11 202.64,81.98 202,81.98 201.5,81.48 201.5,80.21 200.73,79.44
PBAT_PRES1# on TOP: 129.36,150.99 129.11,151.25 129.11,151.93 133.02,155.85 133.5,155.85 133.7,155.64 133.7,155.08 129.61,150.99
PBAT_SMBCLK1 on TOP: 133.4,151.02 133.22,151.2 133.22,151.99 137.13,155.9 137.41,155.9 137.72,155.59 137.72,155.03 133.7,151.02
PBAT_SMBDAT1 on TOP: 131.42,151.02 131.09,151.35 131.09,151.91 135.07,155.9 135.38,155.9 135.68,155.59 135.68,155.03 131.67,151.02
PS_ID_R2 on TOP: 108.6,149.14 108.39,149.35 108.39,150.39 108.18,150.6 108.18,151.45 108.28,151.55 108.28,152.72 107.87,153.13 107.87,154.58 107.98,154.68 109.44,154.68 109.6,154.51 109.6,151.75 110.35,151 110.35,150.23 110.18,150.06 109.6,150.06 109.42,149.88 109.42,149.29 109.27,149.14 ; 1 cut-out
PWR_1D05V_LGATE on TOP: 126.57,117.92 126.44,118.05 126.44,119.96 126.57,120.08 127.2,120.08 127.33,119.96 127.33,117.92
PWR_1D05V_PHASE on TOP: 126.31,112.49 126.18,112.62 126.18,117.42 126.44,117.67 130.25,117.67 130.38,117.54 130.38,116.02 130.5,115.89 132.92,115.89 133.04,115.77 133.04,112.87 132.66,112.49
PWR_1D05V_PHASE on BOTTOM: 125.68,112.46 125.3,112.84 125.3,116.02 125.55,116.27 128.34,116.27 128.85,116.78 132.66,116.78 132.92,116.53 132.92,112.72 132.66,112.46
PWR_1D05V_SNUB on BOTTOM: 125.35,116.78 125.25,116.88 125.25,118.76 125.42,118.94 126.82,118.94 126.95,118.81 126.95,116.91 126.82,116.78 ; 1 cut-out
PWR_1D05V_UGATE on TOP: 133.42,113.86 133.3,113.99 133.3,115.77 133.42,115.89 133.93,115.89 134.06,115.77 134.06,113.99 133.93,113.86
PWR_1D35V_DRVH on TOP: 90.02,11.88 89.9,12 89.9,12.52 90.02,12.64 92.05,12.64 92.14,12.56 92.14,12.01 92.01,11.88 90.37,11.88 90.37,11.88
PWR_1D35V_DRVL on TOP: 94.31,18.74 94.18,18.86 94.18,19.37 94.31,19.5 96.21,19.5 96.34,19.37 96.34,18.86 96.21,18.74
PWR_1D35V_SW on TOP: 89.1,12.9 88.72,13.28 88.72,17.92 90.55,19.75 93.8,19.75 93.8,15.69 93.67,15.56 92.28,15.56 92.15,15.44 92.15,13.02 92.02,12.9
PWR_1D35V_SW on BOTTOM: 89.1,12.9 88.72,13.28 88.72,17.92 89.41,18.61 93,18.61 93.29,18.32 93.29,16.22 93.56,15.96 95.11,15.96 95.26,15.81 95.26,13.29 94.86,12.9
PWR_3D3V_DRVH2 on TOP: 122.12,24.2 121.99,24.33 121.99,26.1 122.12,26.23 122.63,26.23 122.76,26.1 122.76,24.33 122.63,24.2
PWR_3D3V_DRVL2 on TOP: 124.41,28.26 124.28,28.39 124.28,30.17 124.41,30.29 124.91,30.29 125.04,30.17 125.04,28.39 124.91,28.26
PWR_3D3V_LL2 on TOP: 120.01,23.03 119.83,23.21 119.83,26.1 119.96,26.23 121.74,26.23 121.74,24.07 121.87,23.94 123.01,23.94 123.39,24.33 123.39,27.88 123.52,28.01 127.84,28.01 127.96,27.88 127.96,24.49 128.03,24.42 129.72,24.42 129.92,24.22 129.92,23.25 129.7,23.03
PWR_3D3V_LL2 on BOTTOM: 120.01,23.03 119.83,23.21 119.83,27.63 120.22,28.01 127.84,28.01 127.96,27.88 127.96,23.79 127.2,23.03
PWR_5V_DRVH1 on TOP: 139.52,24.2 139.39,24.33 139.39,26.23 140.03,26.23 140.15,26.1 140.15,24.33 140.03,24.2
PWR_5V_DRVL1 on TOP: 132.03,28.26 131.9,28.39 131.9,29.28 132.03,29.41 133.3,29.41 133.3,28.39 133.17,28.26
PWR_5V_LL1 on TOP: 130.29,23.18 130.18,23.29 130.18,24.2 130.39,24.41 131.85,24.41 132.15,24.72 132.15,27.75 132.28,27.88 136.34,27.88 136.47,27.75 136.47,26.48 136.73,26.23 139.01,26.23 139.14,26.1 139.14,23.31 139.01,23.18
PWR_5V_LL1 on BOTTOM: 133.02,23.16 132.41,23.77 132.41,27.37 132.79,27.75 138.5,27.75 139.01,27.25 139.01,23.44 138.73,23.16
PWR_CHG_HIDRV on BOTTOM: 119.58,134.82 119.45,134.94 119.45,135.58 121.36,135.58 121.49,135.45 121.49,134.94 121.36,134.82
PWR_CHG_LODRV on BOTTOM: 115.52,141.67 115.39,141.8 115.39,142.31 115.52,142.44 117.29,142.44 117.42,142.31 117.42,141.67
PWR_CHG_PHASE on BOTTOM: 119.58,135.83 119.45,135.96 119.45,138.63 119.33,138.75 117.8,138.75 117.68,138.88 117.68,142.56 117.8,142.69 124.28,142.69 124.79,142.18 124.79,137.61 123.01,135.83
PWR_DCBATOUT_1D05V on TOP: 130.88,116.27 130.63,116.53 130.63,122.37 131.01,122.75 134.31,122.75 134.44,122.62 134.44,116.4 134.31,116.27 ; 2 cut-outs
PWR_DCBATOUT_1D05V on BOTTOM: 131.24,120.67 130.96,120.95 130.96,122.72 130.99,122.75 133.12,122.75 133.47,122.39 133.47,120.9 133.25,120.67
PWR_DCBATOUT_3D3V on TOP: 119.58,26.48 119.45,26.61 119.45,33.22 119.71,33.47 123.14,33.47 123.26,33.34 123.26,26.74 123.01,26.48 ; 2 cut-outs
PWR_DCBATOUT_3D3V on BOTTOM: 120.22,30.17 119.96,30.42 119.96,33.22 120.22,33.47 123.26,33.47 123.39,33.34 123.39,30.42 123.14,30.17
PWR_DCBATOUT_5V on TOP: 136.98,26.48 136.73,26.74 136.73,29.91 136.47,30.17 136.47,34.23 136.85,34.61 140.54,34.61 140.54,26.61 140.41,26.48 ; 2 cut-outs
PWR_DCBATOUT_5V on BOTTOM: 136.98,29.53 136.73,29.79 136.73,30.93 136.47,31.18 136.47,33.09 136.6,33.22 138.63,33.22 139.27,32.58 139.27,29.79 139.01,29.53
PWR_DCBATOUT_VCCCORE on TOP: 107.26,119.32 107.01,119.58 107.01,121.86 107.13,121.99 109.93,121.99 110.06,121.86 110.06,121.35 110.82,120.59 110.82,119.45 110.69,119.32
PWR_DCBATOUT_VCCCORE on BOTTOM: 107.9,119.32 107.77,119.45 107.77,120.34 107.52,120.59 101.93,120.59 101.8,120.72 101.8,121.35 101.93,121.48 103.32,121.48 103.45,121.61 103.45,124.27 103.71,124.53 109.93,124.53 110.69,123.77 110.69,119.58 110.44,119.32 ; 1 cut-out
PWR_DCBATOUT_VGA_CORE1 on TOP: 156.54,65.22 156.28,65.47 156.28,71.19 160.09,71.19 160.47,70.81 166.44,70.81 166.57,70.68 166.57,65.47 166.32,65.22
PWR_DCBATOUT_VGA_CORE1 on BOTTOM: 156.66,65.22 156.16,65.73 156.16,71.06 156.28,71.19 160.98,71.19 161.36,70.81 166.44,70.81 166.57,70.68 166.57,65.35 166.44,65.22 ; 2 cut-outs
PWR_DCBATOUT_VGA_CORE2 on TOP: 161.24,88.33 160.86,88.71 155.78,88.71 155.55,88.94 155.55,93.49 156.11,94.05 166.44,94.05 166.57,93.92 166.57,88.46 166.44,88.33
PWR_DCBATOUT_VGA_CORE2 on BOTTOM: 161.24,88.33 160.86,88.71 156.28,88.71 156.16,88.84 156.16,93.09 156.36,93.29 159.34,93.29 159.9,93.85 166.51,93.85 166.57,93.79 166.57,88.46 166.44,88.33 ; 2 cut-outs
PWR_DCBATOUT_VRAM_PWR on BOTTOM: 152.98,57.09 152.85,57.22 152.85,59.38 152.98,59.5 158.95,59.5 159.08,59.38 159.08,57.35 158.82,57.09
PWR_VCC_LG on BOTTOM: 101.29,115.77 101.17,115.89 101.17,116.53 101.42,116.78 102.82,116.78 102.94,116.65 102.94,115.89 102.82,115.77
PWR_VCC_PHASE on BOTTOM: 97.23,116.27 96.97,116.53 96.97,122.75 97.23,123 100.4,123 100.66,122.75 100.66,121.23 101.67,120.21 107.13,120.21 107.26,120.08 107.26,117.29 107.13,117.16 101.17,117.16 100.28,116.27
PWR_VCC_UG on BOTTOM: 101.42,121.86 101.29,121.99 101.29,122.75 101.42,122.88 102.82,122.88 102.94,122.75 102.94,121.99 102.82,121.86
PWR_VGA_CORE_LGATE1 on TOP: 161.49,71.32 161.36,71.44 161.36,72.97 162.89,72.97 162.89,71.44 162.76,71.32
PWR_VGA_CORE_LGATE1 on BOTTOM: 161.36,76.01 161.36,77.54 161.49,77.67 162.76,77.67 162.89,77.54 162.89,76.01
PWR_VGA_CORE_LGATE2 on TOP: 161.49,81.6 161.36,81.73 161.36,83.25 162.89,83.25 162.89,81.73 162.76,81.6
PWR_VGA_CORE_LGATE2 on BOTTOM: 161.36,86.3 161.36,87.83 161.49,87.95 162.76,87.95 162.89,87.83 162.89,86.3
PWR_VGA_CORE_PHASE1 on TOP: 167.08,65.47 166.95,65.6 166.95,68.9 167.08,69.03 169.49,69.03 169.75,69.28 169.75,70.17 169.11,70.81 167.08,70.81 166.7,71.19 163.52,71.19 163.27,71.44 163.27,78.17 164.16,79.06 172.16,79.06 172.67,78.55 172.67,67.76 170.38,65.47
PWR_VGA_CORE_PHASE1 on BOTTOM: 167.08,67 166.95,67.12 166.95,70.93 166.7,71.19 163.52,71.19 163.27,71.44 163.27,77.03 163.4,77.16 167.08,77.16 167.46,77.54 167.46,79.32 167.59,79.44 168.35,79.44 168.48,79.32 168.48,77.41 168.73,77.16 171.65,77.16 172.67,76.14 172.67,67.76 171.9,67
PWR_VGA_CORE_PHASE2 on TOP: 163.9,79.82 163.4,80.33 163.4,87.44 163.52,87.57 166.7,87.57 166.95,87.83 166.95,92.14 172.03,92.14 172.67,91.51 172.67,80.46 172.03,79.82
PWR_VGA_CORE_PHASE2 on BOTTOM: 167.59,79.82 167.46,79.95 167.46,81.98 167.33,82.11 163.52,82.11 163.4,82.24 163.4,87.44 163.52,87.57 167.97,87.57 168.86,88.46 169.36,88.46 169.62,88.71 169.62,89.86 169.36,90.11 167.08,90.11 166.95,90.24 166.95,93.67 167.08,93.79 170.38,93.79 172.67,91.51 172.67,83.89 170.89,82.11 168.6,82.11 168.48,81.98 168.48,79.95 168.35,79.82
PWR_VGA_CORE_UGATE1 on TOP: 166.95,69.54 166.95,70.3 169.24,70.3 169.36,70.17 169.36,69.66 169.24,69.54
PWR_VGA_CORE_UGATE1 on BOTTOM: 166.95,65.73 166.95,66.49 169.24,66.49 169.36,66.36 169.36,65.85 169.24,65.73
PWR_VGA_CORE_UGATE2 on TOP: 166.95,92.65 166.95,93.41 169.24,93.41 169.36,93.29 169.36,92.78 169.24,92.65
PWR_VGA_CORE_UGATE2 on BOTTOM: 166.95,88.84 166.95,89.6 169.24,89.6 169.36,89.48 169.36,88.97 169.24,88.84
PWR_VGA_SNUB1 on BOTTOM: 163.9,77.92 163.78,78.05 163.78,79.44 163.9,79.57 166.7,79.57 166.82,79.44 166.82,78.05 166.7,77.92 ; 2 cut-outs
PWR_VGA_SNUB2 on BOTTOM: 164.03,79.82 163.78,80.08 163.78,81.22 164.03,81.48 166.7,81.48 166.82,81.35 166.82,79.95 166.7,79.82 ; 2 cut-outs
REGOUT on BOTTOM: 41.74,62.48 41.7,62.53 41.7,63.31 41.7,63.32 42.48,64.1 43.36,64.1 43.36,64.1 44.46,64.1 44.52,64.15 44.53,64.15 44.89,64.51 47.51,64.51 47.75,64.75 48.7,64.75 48.7,64.75 49.59,64.75 49.76,64.58 49.76,64 49.53,63.77 48.51,63.77 47.74,63 44.02,63 43.65,62.63 42.16,62.63 42.01,62.48 ; 3 cut-outs
RING2_R on TOP: 15.22,1.91 15.01,2.12 15.01,2.96 15.17,3.12 18.5,3.12 18.6,3.01 18.6,1.99 18.52,1.91
RTC_AUX_S5 on TOP: 120.05,54.21 117.96,56.3 117.96,59.73 117.6,60.08 117.6,61.14 114.82,63.93 114.82,67.06 114.12,67.76 114.12,68.9 113.1,69.92 113.1,72.01 113.23,72.14 113.87,72.14 113.99,72.01 113.99,70.62 114.75,69.86 114.75,69.41 115.01,69.16 115.01,67.98 115.94,67.05 115.94,63.92 117.12,62.74 117.12,62.5 117.37,62.25 117.96,62.25 118.36,62.65 119.54,62.65 119.64,62.55 119.64,61.47 119.64,61.47 119.64,60.26 120.34,59.55 121.54,59.55 123.27,61.29 124.01,61.29 124.15,61.14 124.15,60.49 122.71,59.05 119.48,59.05 119.3,58.87 119.3,57.42 121.05,55.67 122.07,55.67 122.15,55.59 122.15,54.52 121.83,54.21 ; 5 cut-outs
SLEEVE on BOTTOM: 32.87,14.82 31.46,16.24 31.46,17.01 31.48,17.03 34.24,17.03 35.67,15.61 35.67,15.04 35.46,14.82
